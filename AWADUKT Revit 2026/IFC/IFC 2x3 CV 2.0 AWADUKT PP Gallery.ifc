Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcFlowFitting: AWADUKT PP SN10 T-Piece:Blue (59)
Name (AWADUKT PP SN10 T-Piece:Blue:...) | 88° | C2 (mm) | C3 (mm) | DSM = DSM R | L1 (mm) | L1+S2 (mm) | S2 (mm) | SmSoK = SmSoK R | Z2 (mm) | Z3 (mm) | Angle (deg) | Angle Check (deg) | Area (m2) | DN1 (mm) = DN3 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) = ID3 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
230935 | no | 602 | 629 | yes | 240 | 247 | 7 | no | 595 | 622 | 45 | 45 | 1.77037 | 315 | 315 | 293.4 | 293.4 | 315 mmø-315 mmø-315 mmø | 0.0125509 | AWADUKT PP BLUE branch DN 315/315, 45 degree | 4064299229890 | 14311331016 | 20.033
230946 | no | 744 | 777 | yes | 293 | 302 | 9 | no | 735 | 768 | 45 | 45 | 2.77663 | 400 | 400 | 372.6 | 372.6 | 400 mmø-400 mmø-400 mmø | 0.0247119 | AWADUKT PP BLUE branch DN 400/400, 45 degree | 4064299240192 | 14311371016 | 39.266
230957 | no | 896 | 941 | yes | 404 | 415 | 11 | no | 885 | 930 | 45 | 45 | 5.0528 | 500 | 500 | 465.8 | 465.8 | 500 mmø-500 mmø-500 mmø | 0.0475168 | AWADUKT PP BLUE branch DN 500/500, 45 degree | 4064299240543 | 14311461016 | 70.01
230968 | no | 1096 | 1155 | yes | 430 | 441 | 11 | no | 1085 | 1144 | 45 | 45 | 7.75569 | 630 | 630 | 586.8 | 586.8 | 630 mmø-630 mmø-630 mmø | 0.0896296 | AWADUKT PP BLUE branch DN 630/630, 45 degree | 4064299240697 | 14311791016 | 122.465
231399 | no | 183 | 168 | no | 91 | 95 | 4 | yes | 179 | 164 | 45 | 45 | 0.291807 | 160 | 110 | 149 | 102.4 | 160 mmø-160 mmø-110 mmø | 0.00112063 | AWADUKT PP BLUE branch DN 160/110, 45 degree | 4007360502348 | 12475011056 | 0.95
231403 | no | 248.8 | 240.8 | no | 111.1 | 115.6 | 4.5 | yes | 244.3 | 236.3 | 45 | 45 | 0.486756 | 200 | 160 | 186.2 | 149 | 200 mmø-200 mmø-160 mmø | 0.00246458 | AWADUKT PP BLUE branch DN 200/160, 45 degree | 4059757761180 | 13244221016 | 2.406
231407 | no | 278 | 282 | no | 162 | 168 | 6 | yes | 272 | 276 | 45 | 45 | 0.693125 | 250 | 160 | 232.8 | 149 | 250 mmø-250 mmø-160 mmø | 0.00428469 | AWADUKT PP BLUE branch 45 deg, DN 250/160 | 4007360363666 | 12477611056 | 4.082
231411 | no | 329 | 319 | no | 130 | 137 | 7 | yes | 322 | 312 | 45 | 45 | 0.914443 | 315 | 160 | 293.4 | 149 | 315 mmø-315 mmø-160 mmø | 0.00683872 | AWADUKT PP BLUE branch DN 315/160, 45 degree | 4007360560904 | 12197781056 | 6.381
231415 | no | 414 | 363 | no | 137 | 146 | 9 | yes | 405 | 354 | 45 | 45 | 1.33133 | 400 | 160 | 372.6 | 149 | 400 mmø-400 mmø-160 mmø | 0.0123972 | AWADUKT PP BLUE branch DN 400/160, 45 degree | 4007360375942 | 12330141026 | 11.54
231419 | no | 611 | 656 | no | 163 | 174 | 11 | yes | 600 | 645 | 45 | 45 | 2.87605 | 500 | 160 | 465.8 | 149 | 500 mmø-500 mmø-160 mmø | 0.0386015 | AWADUKT PP BLUE branch DN 500/160, 45 degree | 4064299239660 | 14314691016 | 33.568
231423 | no | 701 | 786 | no | 98 | 109 | 11 | yes | 690 | 775 | 45 | 45 | 4.18509 | 630 | 160 | 586.8 | 149 | 630 mmø-630 mmø-160 mmø | 0.070612 | AWADUKT PP BLUE branch DN 630/160, 45 degree | 4064299240567 | 14311641016 | 53.987
231787 | no | 296 | 282 | no | 162 | 168 | 6 | yes | 290 | 276 | 45 | 45 | 0.742222 | 250 | 200 | 232.8 | 186.2 | 250 mmø-250 mmø-200 mmø | 0.00471886 | AWADUKT PP BLUE branch DN 250/200, 45 degree | 4067936796120 | 12464571016 | 4.333
231791 | no | 346 | 319 | no | 134 | 141 | 7 | yes | 339 | 312 | 45 | 45 | 0.96506 | 315 | 200 | 293.4 | 186.2 | 315 mmø-315 mmø-200 mmø | 0.00727267 | AWADUKT PP BLUE branch DN 315/200, 45 degree | 4062178644826 | 12197921016 | 6.538
231795 | no | 414 | 363 | no | 137 | 146 | 9 | yes | 405 | 354 | 45 | 45 | 1.36976 | 400 | 200 | 372.6 | 186.2 | 400 mmø-400 mmø-200 mmø | 0.0127071 | AWADUKT PP BLUE branch DN 400/200, 45 degree | 4062178644925 | 12393821056 | 11.66
231799 | no | 641 | 697 | no | 191 | 202 | 11 | yes | 630 | 686 | 45 | 45 | 3.05221 | 500 | 200 | 465.8 | 186.2 | 500 mmø-500 mmø-200 mmø | 0.0409684 | AWADUKT PP BLUE branch DN 500/200, 45 degree | 4064299239677 | 14311421016 | 36.095
231803 | no | 731 | 814 | no | 126 | 137 | 11 | yes | 720 | 803 | 45 | 45 | 4.36371 | 630 | 200 | 586.8 | 186.2 | 630 mmø-630 mmø-200 mmø | 0.0734403 | AWADUKT PP BLUE branch DN 630/200, 45 degree | 4064299240598 | 14311651016 | 56.972
231865 | no | 547 | 582 | yes | 194 | 201 | 7 | no | 540 | 575 | 45 | 45 | 1.48692 | 315 | 250 | 293.4 | 232.8 | 315 mmø-315 mmø-250 mmø | 0.00966403 | AWADUKT PP BLUE branch DN 315/250, 45 degree | 4064299239639 | 14311321016 | 15.601
231869 | no | 609 | 664 | yes | 186 | 195 | 9 | no | 600 | 655 | 45 | 45 | 2.00081 | 400 | 250 | 372.6 | 232.8 | 400 mmø-400 mmø-250 mmø | 0.0155066 | AWADUKT PP BLUE branch DN 400/250, 45 degree | 4064299240130 | 14311341016 | 25.683
231873 | no | 691 | 751 | yes | 227 | 238 | 11 | no | 680 | 740 | 45 | 45 | 3.30723 | 500 | 250 | 465.8 | 232.8 | 500 mmø-500 mmø-250 mmø | 0.0264625 | AWADUKT PP BLUE branch DN 500/250, 45 degree | 4064299240505 | 14311431016 | 40.238
231877 | no | 781 | 860 | yes | 162 | 173 | 11 | no | 770 | 849 | 45 | 45 | 4.63825 | 630 | 250 | 586.8 | 232.8 | 630 mmø-630 mmø-250 mmø | 0.042847 | AWADUKT PP BLUE branch DN 630/250, 45 degree | 4064299240611 | 14311741016 | 62.075
232119 | no | 664 | 714 | yes | 231 | 240 | 9 | no | 655 | 705 | 45 | 45 | 2.29181 | 400 | 315 | 372.6 | 293.4 | 400 mmø-400 mmø-315 mmø | 0.0187048 | AWADUKT PP BLUE branch DN 400/315, 45 degree | 4064299240161 | 14311361016 | 29.961
232123 | no | 741 | 801 | yes | 273 | 284 | 11 | no | 730 | 790 | 45 | 45 | 3.6212 | 500 | 315 | 465.8 | 293.4 | 500 mmø-500 mmø-315 mmø | 0.0303865 | AWADUKT PP BLUE branch DN 500/315, 45 degree | 4064299240512 | 14311441016 | 45.887
232127 | no | 831 | 921 | yes | 208 | 219 | 11 | no | 820 | 910 | 45 | 45 | 5.00894 | 630 | 315 | 586.8 | 293.4 | 630 mmø-630 mmø-315 mmø | 0.0485102 | AWADUKT PP BLUE branch DN 630/315, 45 degree | 4064299240635 | 14311751016 | 69.509
232205 | no | 821 | 866 | yes | 333 | 344 | 11 | no | 810 | 855 | 45 | 45 | 4.11541 | 500 | 400 | 465.8 | 372.6 | 500 mmø-500 mmø-400 mmø | 0.0370345 | AWADUKT PP BLUE branch DN 500/400, 45 degree | 4064299240529 | 14311451016 | 56.049
232209 | no | 911 | 987 | yes | 268 | 279 | 11 | no | 900 | 976 | 45 | 45 | 5.54513 | 630 | 400 | 586.8 | 372.6 | 630 mmø-630 mmø-400 mmø | 0.0567322 | AWADUKT PP BLUE branch DN 630/400, 45 degree | 4064299240659 | 14311771016 | 81.296
232263 | no | 996 | 1054 | yes | 339 | 350 | 11 | no | 985 | 1043 | 45 | 45 | 6.49428 | 630 | 500 | 586.8 | 465.8 | 630 mmø-630 mmø-500 mmø | 0.0683004 | AWADUKT PP BLUE branch DN 630/500, 45 degree | 4064299240673 | 14311781016 | 96.691
232446 | yes | 92 | 92 | no | 170 | 174 | 4 | yes | 88 | 88 | 90 | 88 | 0.304674 | 160 | 160 | 149 | 149 | 160 mmø-160 mmø-160 mmø | 0.00126507 | AWADUKT PP BLUE branch DN 160/160, 90 degree | 4062178644840 | 12217841016 | 1.296
232450 | yes | 125.2 | 125.2 | no | 201.4 | 205.9 | 4.5 | yes | 120.7 | 120.7 | 90 | 88 | 0.467173 | 200 | 200 | 186.2 | 186.2 | 200 mmø-200 mmø-200 mmø | 0.00246584 | AWADUKT PP BLUE branch DN 200/200, 90 degree | 4062178644987 | 13245231016 | 2.327
232454 | no | 241 | 216 | no | 290 | 296 | 6 | yes | 235 | 210 | 90 | 90 | 0.857366 | 250 | 250 | 232.8 | 232.8 | 250 mmø-250 mmø-250 mmø | 0.0059501 | AWADUKT PP BLUE branch DN 250/250, 90 degree | 4062178644901 | 12350991016 | 7.534
232458 | no | 332 | 332 | yes | 342 | 349 | 7 | no | 325 | 325 | 90 | 90 | 1.3868 | 315 | 315 | 293.4 | 293.4 | 315 mmø-315 mmø-315 mmø | 0.00845995 | AWADUKT PP BLUE branch DN 315/315, 90 degree | 4064299240970 | 14311881016 | 15.868
232462 | no | 419 | 419 | yes | 410 | 419 | 9 | no | 410 | 410 | 90 | 90 | 2.18774 | 400 | 400 | 372.6 | 372.6 | 400 mmø-400 mmø-400 mmø | 0.0168085 | AWADUKT PP BLUE branch DN 400/400, 90 degree | 4064299241533 | 14311951016 | 31.154
232466 | no | 510 | 510 | yes | 550 | 561 | 11 | no | 499 | 499 | 90 | 90 | 4.18824 | 500 | 500 | 465.8 | 465.8 | 500 mmø-500 mmø-500 mmø | 0.0330644 | AWADUKT PP BLUE branch DN 500/500, 90 degree | 4064299241656 | 14312081016 | 55.07
232470 | no | 601 | 601 | yes | 615 | 626 | 11 | no | 590 | 590 | 90 | 90 | 6.34871 | 630 | 630 | 586.8 | 586.8 | 630 mmø-630 mmø-630 mmø | 0.0598656 | AWADUKT PP BLUE branch DN 630/630, 90 degree | 4064299296328 | 14312171016 | 92.007
232495 | yes | 122 | 105.1 | no | 179.5 | 184 | 4.5 | yes | 117.5 | 100.6 | 90 | 88 | 0.405626 | 200 | 160 | 186.2 | 149 | 200 mmø-200 mmø-160 mmø | 0.00197939 | AWADUKT PP BLUE branch DN 200/160, 90 degree | 4062178644970 | 13245221016 | 1.906
232499 | no | 241 | 166 | no | 245 | 251 | 6 | yes | 235 | 160 | 90 | 90 | 0.676771 | 250 | 160 | 232.8 | 149 | 250 mmø-250 mmø-160 mmø | 0.00414925 | AWADUKT PP BLUE branch DN 250/160, 90 degree | 4062178644895 | 12322571016 | 5.158
232503 | no | 289 | 300 | yes | 299 | 306 | 7 | no | 282 | 293 | 90 | 90 | 1.07143 | 315 | 160 | 293.4 | 149 | 315 mmø-315 mmø-160 mmø | 0.00630564 | AWADUKT PP BLUE branch DN 315/160, 90 degree | 4064299240918 | 14311821016 | 9.337
232507 | no | 344 | 299 | yes | 290 | 299 | 9 | no | 335 | 290 | 90 | 90 | 1.44654 | 400 | 160 | 372.6 | 149 | 400 mmø-400 mmø-160 mmø | 0.00981867 | AWADUKT PP BLUE branch DN 400/160, 90 degree | 4064299240994 | 14311911016 | 17.913
232511 | no | 406 | 340 | yes | 380 | 391 | 11 | no | 395 | 329 | 90 | 90 | 2.6769 | 500 | 160 | 465.8 | 149 | 500 mmø-500 mmø-160 mmø | 0.0185412 | AWADUKT PP BLUE branch DN 500/160, 90 degree | 4064299241557 | 14312011016 | 30.689
232515 | no | 471 | 366 | yes | 380 | 391 | 11 | no | 460 | 355 | 90 | 90 | 3.87221 | 630 | 160 | 586.8 | 149 | 630 mmø-630 mmø-160 mmø | 0.0304231 | AWADUKT PP BLUE branch DN 630/160, 90 degree | 4064299295901 | 14312091016 | 47.897
232520 | no | 241 | 186 | no | 265 | 271 | 6 | yes | 235 | 180 | 90 | 90 | 0.74736 | 250 | 200 | 232.8 | 186.2 | 250 mmø-250 mmø-200 mmø | 0.00479732 | AWADUKT PP BLUE branch DN 250/200, 90 degree | 4062178644888 | 12315071016 | 5.715
232524 | no | 295 | 300 | yes | 299 | 306 | 7 | no | 288 | 293 | 90 | 90 | 1.11562 | 315 | 200 | 293.4 | 186.2 | 315 mmø-315 mmø-200 mmø | 0.00646439 | AWADUKT PP BLUE branch DN 315/200, 90 degree | 4064299240932 | 14311831016 | 10.824
232528 | no | 349 | 319 | yes | 310 | 319 | 9 | no | 340 | 310 | 90 | 90 | 1.53932 | 400 | 200 | 372.6 | 186.2 | 400 mmø-400 mmø-200 mmø | 0.0106217 | AWADUKT PP BLUE branch DN 400/200, 90 degree | 4064299241298 | 14311921016 | 19.065
232532 | no | 411 | 360 | yes | 400 | 411 | 11 | no | 400 | 349 | 90 | 90 | 2.7829 | 500 | 200 | 465.8 | 186.2 | 500 mmø-500 mmø-200 mmø | 0.0196983 | AWADUKT PP BLUE branch DN 500/200, 90 degree | 4064299241571 | 14312021016 | 32.259
232536 | no | 476 | 386 | yes | 400 | 411 | 11 | no | 465 | 375 | 90 | 90 | 3.99418 | 630 | 200 | 586.8 | 186.2 | 630 mmø-630 mmø-200 mmø | 0.0321516 | AWADUKT PP BLUE branch DN 630/200, 90 degree | 4064299295925 | 14312111016 | 50.007
232541 | no | 314 | 300 | yes | 299 | 306 | 7 | no | 307 | 293 | 90 | 90 | 1.19339 | 315 | 250 | 293.4 | 232.8 | 315 mmø-315 mmø-250 mmø | 0.00684104 | AWADUKT PP BLUE branch DN 315/250, 90 degree | 4064299240956 | 14311841016 | 13.269
232545 | no | 369 | 344 | yes | 335 | 344 | 9 | no | 360 | 335 | 90 | 90 | 1.67773 | 400 | 250 | 372.6 | 232.8 | 400 mmø-400 mmø-250 mmø | 0.0117966 | AWADUKT PP BLUE branch DN 400/250, 90 degree | 4064299240833 | 14311931016 | 21.23
232549 | no | 431 | 385 | yes | 425 | 436 | 11 | no | 420 | 374 | 90 | 90 | 2.93708 | 500 | 250 | 465.8 | 232.8 | 500 mmø-500 mmø-250 mmø | 0.0213048 | AWADUKT PP BLUE branch DN 500/250, 90 degree | 4064299241595 | 14312031016 | 34.834
232553 | no | 496 | 411 | yes | 425 | 436 | 11 | no | 485 | 400 | 90 | 90 | 4.16786 | 630 | 250 | 586.8 | 232.8 | 630 mmø-630 mmø-250 mmø | 0.0344558 | AWADUKT PP BLUE branch DN 630/250, 90 degree | 4064299295949 | 14312121016 | 53.338
232574 | no | 387 | 376 | yes | 361 | 370 | 9 | no | 378 | 367 | 90 | 90 | 1.85884 | 400 | 315 | 372.6 | 293.4 | 400 mmø-400 mmø-315 mmø | 0.0134429 | AWADUKT PP BLUE branch DN 400/315, 90 degree | 4064299241519 | 14311941016 | 24.517
232578 | no | 449 | 418 | yes | 457 | 468 | 11 | no | 438 | 407 | 90 | 90 | 3.14503 | 500 | 315 | 465.8 | 293.4 | 500 mmø-500 mmø-315 mmø | 0.0235981 | AWADUKT PP BLUE branch DN 500/315, 90 degree | 4064299241618 | 14312041016 | 38.802
232582 | no | 514 | 444 | yes | 457 | 468 | 11 | no | 503 | 433 | 90 | 90 | 4.39995 | 630 | 315 | 586.8 | 293.4 | 630 mmø-630 mmø-315 mmø | 0.0376152 | AWADUKT PP BLUE branch DN 630/315, 90 degree | 4064299295963 | 14312131016 | 58.192
232599 | no | 481 | 460 | yes | 500 | 511 | 11 | no | 470 | 449 | 90 | 90 | 3.47319 | 500 | 400 | 465.8 | 372.6 | 500 mmø-500 mmø-400 mmø | 0.0272984 | AWADUKT PP BLUE branch DN 500/400, 90 degree | 4064299241632 | 14312071016 | 45.935
232603 | no | 546 | 486 | yes | 500 | 511 | 11 | no | 535 | 475 | 90 | 90 | 4.75558 | 630 | 400 | 586.8 | 372.6 | 630 mmø-630 mmø-400 mmø | 0.0423725 | AWADUKT PP BLUE branch DN 630/400, 90 degree | 4064299295987 | 14312141016 | 66.399
232616 | no | 575 | 536 | yes | 550 | 561 | 11 | no | 564 | 525 | 90 | 90 | 5.47823 | 630 | 500 | 586.8 | 465.8 | 630 mmø-630 mmø-500 mmø | 0.0489 | AWADUKT PP BLUE branch DN 630/500, 90 degree | 4064299296304 | 14312151016 | 76.56
242064 | no | 194 | 139 | yes | 172 | 176 | 4 | no | 190 | 135 | 90 | 90 | 0.332424 | 160 | 110 | 149 | 102.4 | 160 mmø-160 mmø-110 mmø | 0.000931184 | AWADUKT PP BLUE branch DN 160/110, 90 degree | 4062178644833 | 12217831016 | 1.747

# IfcFlowFitting: AWADUKT PP SN10 T-Piece:Orange (59)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; DN1 DSM: AWADUKT PP Union DSM : Orange No PID; DN3 DSM: AWADUKT PP Union DSM : Orange; Family Name: AWADUKT PP SN10 T-Piece; T1: APP DSM; T2: DAPP SN10 T-Piece; T3: APP SN10 T-Piece
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Orange; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP SN10 T-Piece:Orange; sets with these values: 2
Other - IsCustom: no; C Left: no; C Right: yes; DSM L: yes; DSM PID L: no; DSM PID R: no; Family: AWADUKT PP SN10 T-Piece; SmSoK L: no; Type: Orange; Family and Type: AWADUKT PP SN10 T-Piece: Orange; Type Id: 219596
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP SN10 T-Piece:Orange:...) | 88° | DSM = DSM R | SmSoK = SmSoK R | C2 (mm) | C3 (mm) | L1 (mm) | L1+S2 (mm) | S2 (mm) | Z2 (mm) | Z3 (mm) | Angle (deg) | Angle Check (deg) | Area (m2) | DN1 (mm) = DN3 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) = ID3 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
282444 | no | no | yes | 144 | 144 | 88 | 92 | 4 | 140 | 140 | 45 | 45 | 0.193336 | 110 | 110 | 102.4 | 102.4 | 110 mmø-110 mmø-110 mmø | 0.000573948 | AWADUKT PP branch DN 110/110, 45 degree | 4007360242275 | 12474911001 | 0.672
282448 | no | no | yes | 208 | 208 | 124 | 128 | 4 | 204 | 204 | 45 | 45 | 0.379363 | 160 | 160 | 149 | 149 | 160 mmø-160 mmø-160 mmø | 0.00166349 | AWADUKT PP branch DN 160/160, 45 degree | 4007360335472 | 12475111002 | 1.698
282452 | no | no | yes | 274.5 | 274.5 | 140.4 | 144.9 | 4.5 | 270 | 270 | 45 | 45 | 0.586839 | 200 | 200 | 186.2 | 186.2 | 200 mmø-200 mmø-200 mmø | 0.00327274 | AWADUKT PP branch DN 200/200, 45 degree | 4059757761135 | 13244231001 | 3.064
282456 | no | no | yes | 468 | 469 | 217 | 223 | 6 | 462 | 463 | 45 | 45 | 1.12774 | 250 | 250 | 232.8 | 232.8 | 250 mmø-250 mmø-250 mmø | 0.00823348 | AWADUKT PP branch DN 250/250, 45 degree | 4007360270803 | 12376741005 | 12.659
282460 | no | yes | no | 602 | 629 | 240 | 247 | 7 | 595 | 622 | 45 | 45 | 1.77037 | 315 | 315 | 293.4 | 293.4 | 315 mmø-315 mmø-315 mmø | 0.0125509 | AWADUKT PP branch DN 315/315, 45 degree | 4064299229883 | 14311331001 | 20.033
282464 | no | yes | no | 744 | 777 | 293 | 302 | 9 | 735 | 768 | 45 | 45 | 2.77663 | 400 | 400 | 372.6 | 372.6 | 400 mmø-400 mmø-400 mmø | 0.0247119 | AWADUKT PP branch DN 400/400, 45 degree | 4064299240185 | 14311371005 | 39.266
282468 | no | yes | no | 896 | 941 | 404 | 415 | 11 | 885 | 930 | 45 | 45 | 5.0528 | 500 | 500 | 465.8 | 465.8 | 500 mmø-500 mmø-500 mmø | 0.0475168 | AWADUKT PP branch DN 500/500, 45 degree | 4064299240536 | 14311461005 | 70.01
282472 | no | yes | no | 1096 | 1155 | 430 | 441 | 11 | 1085 | 1144 | 45 | 45 | 7.75569 | 630 | 630 | 586.8 | 586.8 | 630 mmø-630 mmø-630 mmø | 0.0896296 | AWADUKT PP branch DN 630/630, 45 degree | 4064299240680 | 14311791005 | 122.465
282492 | no | no | yes | 183 | 168 | 91 | 95 | 4 | 179 | 164 | 45 | 45 | 0.291807 | 160 | 110 | 149 | 102.4 | 160 mmø-160 mmø-110 mmø | 0.00112063 | AWADUKT PP branch DN 160/110, 45 degree | 4007360242282 | 12475011001 | 0.95
282496 | no | no | yes | 248.8 | 240.8 | 111.1 | 115.6 | 4.5 | 244.3 | 236.3 | 45 | 45 | 0.486756 | 200 | 160 | 186.2 | 149 | 200 mmø-200 mmø-160 mmø | 0.00246458 | AWADUKT PP branch DN 200/160, 45 degree | 4059757761142 | 13244221001 | 2.406
282500 | no | no | yes | 278 | 282 | 162 | 168 | 6 | 272 | 276 | 45 | 45 | 0.693125 | 250 | 160 | 232.8 | 149 | 250 mmø-250 mmø-160 mmø | 0.00428469 | AWADUKT PP branch DN 250/160, 45 degree | 4007360560911 | 13147561002 | 4.029
282504 | no | no | yes | 329 | 319 | 130 | 137 | 7 | 322 | 312 | 45 | 45 | 0.914443 | 315 | 160 | 293.4 | 149 | 315 mmø-315 mmø-160 mmø | 0.00683872 | AWADUKT PP branch DN 315/160, 45 degree | 4007360554095 | 12197781002 | 6.335
282508 | no | no | yes | 414 | 363 | 137 | 146 | 9 | 405 | 354 | 45 | 45 | 1.33133 | 400 | 160 | 372.6 | 149 | 400 mmø-400 mmø-160 mmø | 0.0123972 | AWADUKT PP branch DN 400/160, 45 degree | 4007360384159 | 12330141002 | 11.54
282512 | no | no | yes | 611 | 656 | 163 | 174 | 11 | 600 | 645 | 45 | 45 | 2.87605 | 500 | 160 | 465.8 | 149 | 500 mmø-500 mmø-160 mmø | 0.0386015 | AWADUKT PP branch DN 500/160, 45 degree | 4064299239394 | 14314691005 | 33.568
282516 | no | no | yes | 701 | 786 | 98 | 109 | 11 | 690 | 775 | 45 | 45 | 4.18509 | 630 | 160 | 586.8 | 149 | 630 mmø-630 mmø-160 mmø | 0.070612 | AWADUKT PP branch DN 630/160, 45 degree | 4064299240574 | 14311641005 | 53.987
282520 | no | no | yes | 296 | 282 | 162 | 168 | 6 | 290 | 276 | 45 | 45 | 0.742222 | 250 | 200 | 232.8 | 186.2 | 250 mmø-250 mmø-200 mmø | 0.00471886 | AWADUKT PP branch DN 250/200, 45 degree | 4007360560935 | 13147571002 | 4.456
282524 | no | no | yes | 346 | 319 | 134 | 141 | 7 | 339 | 312 | 45 | 45 | 0.96506 | 315 | 200 | 293.4 | 186.2 | 315 mmø-315 mmø-200 mmø | 0.00727267 | AWADUKT PP branch DN 315/200, 45 degree | 4007360561000 | 12197921002 | 6.538
282528 | no | no | yes | 414 | 363 | 137 | 146 | 9 | 405 | 354 | 45 | 45 | 1.36976 | 400 | 200 | 372.6 | 186.2 | 400 mmø-400 mmø-200 mmø | 0.0127071 | AWADUKT PP branch DN 400/200, 45 degree | 4007360384203 | 12393821002 | 11.66
282532 | no | no | yes | 641 | 697 | 191 | 202 | 11 | 630 | 686 | 45 | 45 | 3.05221 | 500 | 200 | 465.8 | 186.2 | 500 mmø-500 mmø-200 mmø | 0.0409684 | AWADUKT PP branch DN 500/200, 45 degree | 4064299240420 | 14311421005 | 36.095
282536 | no | no | yes | 731 | 814 | 126 | 137 | 11 | 720 | 803 | 45 | 45 | 4.36371 | 630 | 200 | 586.8 | 186.2 | 630 mmø-630 mmø-200 mmø | 0.0734403 | AWADUKT PP branch DN 630/200, 45 degree | 4064299240581 | 14311651005 | 56.972
282540 | no | yes | no | 547 | 582 | 194 | 201 | 7 | 540 | 575 | 45 | 45 | 1.48692 | 315 | 250 | 293.4 | 232.8 | 315 mmø-315 mmø-250 mmø | 0.00966403 | AWADUKT PP branch DN 315/250, 45 degree | 4064299239622 | 14311321001 | 15.601
282544 | no | yes | no | 609 | 664 | 186 | 195 | 9 | 600 | 655 | 45 | 45 | 2.00081 | 400 | 250 | 372.6 | 232.8 | 400 mmø-400 mmø-250 mmø | 0.0155066 | AWADUKT PP branch DN 400/250, 45 degree | 4064299240123 | 14311341001 | 25.683
282548 | no | yes | no | 691 | 751 | 227 | 238 | 11 | 680 | 740 | 45 | 45 | 3.30723 | 500 | 250 | 465.8 | 232.8 | 500 mmø-500 mmø-250 mmø | 0.0264625 | AWADUKT PP branch DN 500/250, 45 degree | 4064299240444 | 14311431005 | 40.238
282552 | no | yes | no | 781 | 860 | 162 | 173 | 11 | 770 | 849 | 45 | 45 | 4.63825 | 630 | 250 | 586.8 | 232.8 | 630 mmø-630 mmø-250 mmø | 0.042847 | AWADUKT PP branch DN 630/250, 45 degree | 4064299240604 | 14311741005 | 62.075
282572 | no | yes | no | 664 | 714 | 231 | 240 | 9 | 655 | 705 | 45 | 45 | 2.29181 | 400 | 315 | 372.6 | 293.4 | 400 mmø-400 mmø-315 mmø | 0.0187048 | AWADUKT PP branch DN 400/315, 45 degree | 4064299240154 | 14311361001 | 29.961
282576 | no | yes | no | 741 | 801 | 273 | 284 | 11 | 730 | 790 | 45 | 45 | 3.6212 | 500 | 315 | 465.8 | 293.4 | 500 mmø-500 mmø-315 mmø | 0.0303865 | AWADUKT PP branch DN 500/315, 45 degree | 4064299240468 | 14311441005 | 45.887
282580 | no | yes | no | 831 | 921 | 208 | 219 | 11 | 820 | 910 | 45 | 45 | 5.00894 | 630 | 315 | 586.8 | 293.4 | 630 mmø-630 mmø-315 mmø | 0.0485102 | AWADUKT PP branch DN 630/315, 45 degree | 4064299240628 | 14311751005 | 69.509
282596 | no | yes | no | 821 | 866 | 333 | 344 | 11 | 810 | 855 | 45 | 45 | 4.11541 | 500 | 400 | 465.8 | 372.6 | 500 mmø-500 mmø-400 mmø | 0.0370345 | AWADUKT PP branch DN 500/400, 45 degree | 4064299240482 | 14311451005 | 56.049
282600 | no | yes | no | 911 | 987 | 268 | 279 | 11 | 900 | 976 | 45 | 45 | 5.54513 | 630 | 400 | 586.8 | 372.6 | 630 mmø-630 mmø-400 mmø | 0.0567322 | AWADUKT PP branch DN 630/400, 45 degree | 4064299240642 | 14311771005 | 81.296
282612 | no | yes | no | 996 | 1054 | 339 | 350 | 11 | 985 | 1043 | 45 | 45 | 6.49428 | 630 | 500 | 586.8 | 465.8 | 630 mmø-630 mmø-500 mmø | 0.0683004 | AWADUKT PP branch DN 630/500, 45 degree | 4064299240666 | 14311781005 | 96.691
282620 | yes | no | yes | 92 | 92 | 170 | 174 | 4 | 88 | 88 | 90 | 88 | 0.304674 | 160 | 160 | 149 | 149 | 160 mmø-160 mmø-160 mmø | 0.00126507 | AWADUKT PP branch DN 160/160, 90 degree | 4007360335465 | 12217841002 | 1.297
282624 | yes | no | yes | 125.2 | 125.2 | 201.4 | 205.9 | 4.5 | 120.7 | 120.7 | 90 | 88 | 0.467173 | 200 | 200 | 186.2 | 186.2 | 200 mmø-200 mmø-200 mmø | 0.00246584 | AWADUKT PP branch DN 200/200, 90 degree | 4059757761159 | 13245231001 | 2.327
282628 | no | no | yes | 241 | 216 | 290 | 296 | 6 | 235 | 210 | 90 | 90 | 0.857366 | 250 | 250 | 232.8 | 232.8 | 250 mmø-250 mmø-250 mmø | 0.0059501 | AWADUKT PP branch DN 250/250, 90 degree | 4007360271046 | 12350991005 | 7.556
282632 | no | yes | no | 332 | 332 | 342 | 349 | 7 | 325 | 325 | 90 | 90 | 1.3868 | 315 | 315 | 293.4 | 293.4 | 315 mmø-315 mmø-315 mmø | 0.00845995 | AWADUKT PP branch DN 315/315, 90 degree | 4064299240963 | 14311881005 | 15.868
282636 | no | yes | no | 419 | 419 | 410 | 419 | 9 | 410 | 410 | 90 | 90 | 2.18774 | 400 | 400 | 372.6 | 372.6 | 400 mmø-400 mmø-400 mmø | 0.0168085 | AWADUKT PP branch DN 400/400, 90 degree | 4064299241526 | 14311951005 | 31.154
282640 | no | yes | no | 510 | 510 | 550 | 561 | 11 | 499 | 499 | 90 | 90 | 4.18824 | 500 | 500 | 465.8 | 465.8 | 500 mmø-500 mmø-500 mmø | 0.0330644 | AWADUKT PP branch DN 500/500, 90 degree | 4064299241649 | 14312081005 | 55.07
282644 | no | yes | no | 601 | 601 | 615 | 626 | 11 | 590 | 590 | 90 | 90 | 6.34871 | 630 | 630 | 586.8 | 586.8 | 630 mmø-630 mmø-630 mmø | 0.0598656 | AWADUKT PP branch DN 630/630, 90 degree | 4064299296311 | 14312171005 | 92.007
282648 | yes | no | yes | 122 | 105.1 | 179.5 | 184 | 4.5 | 117.5 | 100.6 | 90 | 88 | 0.405626 | 200 | 160 | 186.2 | 149 | 200 mmø-200 mmø-160 mmø | 0.00197939 | AWADUKT PP branch DN 200/160, 90 degree | 4059757761166 | 13245221001 | 1.906
282652 | no | no | yes | 241 | 166 | 245 | 251 | 6 | 235 | 160 | 90 | 90 | 0.676771 | 250 | 160 | 232.8 | 149 | 250 mmø-250 mmø-160 mmø | 0.00414925 | AWADUKT PP branch DN 250/160, 90 degree | 4007360271022 | 12322571005 | 4.953
282656 | no | yes | no | 289 | 300 | 299 | 306 | 7 | 282 | 293 | 90 | 90 | 1.07143 | 315 | 160 | 293.4 | 149 | 315 mmø-315 mmø-160 mmø | 0.00630564 | AWADUKT PP branch DN 315/160, 90 degree | 4064299240901 | 14311821005 | 9.663
282660 | no | yes | no | 344 | 299 | 290 | 299 | 9 | 335 | 290 | 90 | 90 | 1.44654 | 400 | 160 | 372.6 | 149 | 400 mmø-400 mmø-160 mmø | 0.00981867 | AWADUKT PP branch DN 400/160, 90 degree | 4064299240987 | 14311911005 | 17.913
282664 | no | yes | no | 406 | 340 | 380 | 391 | 11 | 395 | 329 | 90 | 90 | 2.6769 | 500 | 160 | 465.8 | 149 | 500 mmø-500 mmø-160 mmø | 0.0185412 | AWADUKT PP branch DN 500/160, 90 degree | 4064299241540 | 14312011005 | 30.689
282668 | no | yes | no | 471 | 366 | 380 | 391 | 11 | 460 | 355 | 90 | 90 | 3.87221 | 630 | 160 | 586.8 | 149 | 630 mmø-630 mmø-160 mmø | 0.0304231 | AWADUKT PP branch DN 630/160, 90 degree | 4064299290791 | 14312091005 | 47.897
282672 | no | no | yes | 241 | 186 | 265 | 271 | 6 | 235 | 180 | 90 | 90 | 0.74736 | 250 | 200 | 232.8 | 186.2 | 250 mmø-250 mmø-200 mmø | 0.00479732 | AWADUKT PP branch DN 250/200, 90 degree | 4007360271039 | 12315071005 | 5.94
282676 | no | yes | no | 295 | 300 | 299 | 306 | 7 | 288 | 293 | 90 | 90 | 1.11562 | 315 | 200 | 293.4 | 186.2 | 315 mmø-315 mmø-200 mmø | 0.00646439 | AWADUKT PP branch DN 315/200, 90 degree | 4064299240925 | 14311831005 | 11.011
282680 | no | yes | no | 349 | 319 | 310 | 319 | 9 | 340 | 310 | 90 | 90 | 1.53932 | 400 | 200 | 372.6 | 186.2 | 400 mmø-400 mmø-200 mmø | 0.0106217 | AWADUKT PP branch DN 400/200, 90 degree | 4064299241007 | 14311921005 | 19.065
282684 | no | yes | no | 411 | 360 | 400 | 411 | 11 | 400 | 349 | 90 | 90 | 2.7829 | 500 | 200 | 465.8 | 186.2 | 500 mmø-500 mmø-200 mmø | 0.0196983 | AWADUKT PP branch DN 500/200, 90 degree | 4064299241564 | 14312021005 | 32.259
282688 | no | yes | no | 476 | 386 | 400 | 411 | 11 | 465 | 375 | 90 | 90 | 3.99418 | 630 | 200 | 586.8 | 186.2 | 630 mmø-630 mmø-200 mmø | 0.0321516 | AWADUKT PP branch DN 630/200, 90 degree | 4064299295918 | 14312111005 | 50.007
282692 | no | yes | no | 314 | 300 | 299 | 306 | 7 | 307 | 293 | 90 | 90 | 1.19339 | 315 | 250 | 293.4 | 232.8 | 315 mmø-315 mmø-250 mmø | 0.00684104 | AWADUKT PP branch DN 315/250, 90 degree | 4064299240949 | 14311841005 | 12.905
282696 | no | yes | no | 369 | 344 | 335 | 344 | 9 | 360 | 335 | 90 | 90 | 1.67773 | 400 | 250 | 372.6 | 232.8 | 400 mmø-400 mmø-250 mmø | 0.0117966 | AWADUKT PP branch DN 400/250, 90 degree | 4064299241014 | 14311931005 | 21.23
282700 | no | yes | no | 431 | 385 | 425 | 436 | 11 | 420 | 374 | 90 | 90 | 2.93708 | 500 | 250 | 465.8 | 232.8 | 500 mmø-500 mmø-250 mmø | 0.0213048 | AWADUKT PP branch DN 500/250, 90 degree | 4064299241588 | 14312031005 | 34.834
282704 | no | yes | no | 496 | 411 | 425 | 436 | 11 | 485 | 400 | 90 | 90 | 4.16786 | 630 | 250 | 586.8 | 232.8 | 630 mmø-630 mmø-250 mmø | 0.0344558 | AWADUKT PP branch DN 630/250, 90 degree | 4064299295932 | 14312121005 | 53.338
282708 | no | yes | no | 387 | 376 | 361 | 370 | 9 | 378 | 367 | 90 | 90 | 1.85884 | 400 | 315 | 372.6 | 293.4 | 400 mmø-400 mmø-315 mmø | 0.0134429 | AWADUKT PP branch DN 400/315, 90 degree | 4064299241502 | 14311941005 | 24.517
282712 | no | yes | no | 449 | 418 | 457 | 468 | 11 | 438 | 407 | 90 | 90 | 3.14503 | 500 | 315 | 465.8 | 293.4 | 500 mmø-500 mmø-315 mmø | 0.0235981 | AWADUKT PP branch DN 500/315, 90 degree | 4064299241601 | 14312041005 | 38.802
282716 | no | yes | no | 514 | 444 | 457 | 468 | 11 | 503 | 433 | 90 | 90 | 4.39995 | 630 | 315 | 586.8 | 293.4 | 630 mmø-630 mmø-315 mmø | 0.0376152 | AWADUKT PP branch DN 630/315, 90 degree | 4064299295956 | 14312131005 | 58.192
282720 | no | yes | no | 481 | 460 | 500 | 511 | 11 | 470 | 449 | 90 | 90 | 3.47319 | 500 | 400 | 465.8 | 372.6 | 500 mmø-500 mmø-400 mmø | 0.0272984 | AWADUKT PP branch DN 500/400, 90 degree | 4064299241625 | 14312071005 | 45.935
282724 | no | yes | no | 546 | 486 | 500 | 511 | 11 | 535 | 475 | 90 | 90 | 4.75558 | 630 | 400 | 586.8 | 372.6 | 630 mmø-630 mmø-400 mmø | 0.0423725 | AWADUKT PP branch DN 630/400, 90 degree | 4064299295970 | 14312141005 | 66.399
282728 | no | yes | no | 575 | 536 | 550 | 561 | 11 | 564 | 525 | 90 | 90 | 5.47823 | 630 | 500 | 586.8 | 465.8 | 630 mmø-630 mmø-500 mmø | 0.0489 | AWADUKT PP branch DN 630/500, 90 degree | 4064299295994 | 14312151005 | 76.56
282732 | no | yes | no | 194 | 139 | 172 | 176 | 4 | 190 | 135 | 90 | 90 | 0.332424 | 160 | 110 | 149 | 102.4 | 160 mmø-160 mmø-110 mmø | 0.000931184 | AWADUKT PP branch DN 160/110, 90 degree | 4007360270988 | 12217831005 | 1.747

# IfcFlowFitting: AWADUKT PP Transition:Blue (7)
In: Ground floor
Type - Material: AWADUKT PP SN10 Blue
Type - Other - Category: Pipe Fittings; DN1 DSM: AWADUKT PP Union DSM : Blue No PID; Family Name: AWADUKT PP Transition; T1: DAPP SN10 Transition; T2: APP SN10 Transition
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Blue; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Blue
Type - Materials and Finishes - APP: AWADUKT PP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP Transition:Blue; sets with these values: 2
Other - IsCustom: no; Type: Blue; Family: AWADUKT PP Transition; Family and Type: AWADUKT PP Transition: Blue; Type Id: 226871
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Dimensions - OffsetHeight: 0; OffsetWidth: 0
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Transition:Blue:...) | L1 (mm) | XC1 (mm) | XS1 (mm) | XS1/2 (mm) | XS2 (mm) | YD1 (mm) | YD2 (mm) | YL1 (mm) | Area (m2) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
257141 | 105 | 112.5 | 3 | 1.5 | 4.5 | 208.3 | 150.4 | 18.4 | 0.145341 | 200 | 160 | 186.2 | 149 | 200 mmø-160 mmø | 0.000773333 | AWADUKT PP BLUE reduction DN 200/160 | 4007360353797 | 12477911056 | 0.898
281361 | 143 | 153 | 4 | 2 | 6 | 260.3 | 187.8 | 23 | 0.232497 | 250 | 200 | 232.8 | 186.2 | 250 mmø-200 mmø | 0.00158097 | - | - | - | 0
281374 | 150 | 162 | 5 | 2.5 | 7 | 327.3 | 232.8 | 31.7 | 0.324414 | 315 | 250 | 293.4 | 232.8 | 315 mmø-250 mmø | 0.00260838 | AWADUKT PP BLUE reduction DN 250/200 | 4062178644949 | 12478011016 | 1.718
281385 | 223 | 242 | 10 | 5 | 9 | 450 | 292.8 | 40.7 | 0.562461 | 400 | 315 | 372.6 | 293.4 | 400 mmø-315 mmø | 0.0059292 | AWADUKT PP BLUE reduction DN 400/315 | 4062178590352 | 12373231016 | 4.924
281398 | 263 | 288 | 14 | 7 | 11 | 550 | 372.1 | 48.3 | 0.812234 | 500 | 400 | 465.8 | 372.6 | 500 mmø-400 mmø | 0.0110476 | AWADUKT PP BLUE reduction DN 500/400 | 4062178590369 | 12346261016 | 9.855
281409 | 315 | 341 | 15 | 7.5 | 11 | 700 | 466.1 | 61.9 | 1.24279 | 630 | 500 | 586.8 | 465.8 | 630 mmø-500 mmø | 0.0207494 | AWADUKT PP BLUE reduction DN 630/500 | 4062178590376 | 14115521016 | 18.19
283562 | 86.4 | 92.9 | 2.5 | 1.25 | 4 | 168 | 101 | 24.3 | 0.0965827 | 160 | 110 | 149 | 102.4 | 160 mmø-110 mmø | 0.000489684 | - | - | - | 0

# IfcFlowFitting: AWADUKT PP Transition:Orange (7)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; DN1 DSM: AWADUKT PP Union DSM : Orange No PID; Family Name: AWADUKT PP Transition; T1: DAPP SN10 Transition; T2: APP SN10 Transition
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Orange; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP Transition:Orange; sets with these values: 2
Other - IsCustom: no; Family: AWADUKT PP Transition; Type: Orange; Family and Type: AWADUKT PP Transition: Orange; Type Id: 226869
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Dimensions - OffsetHeight: 0; OffsetWidth: 0
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Transition:Orange:...) | L1 (mm) | XC1 (mm) | XS1 (mm) | XS1/2 (mm) | XS2 (mm) | YD1 (mm) | YD2 (mm) | YL1 (mm) | Area (m2) | DN1 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | ID1 (mm) | ID2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
282860 | 105 | 112.5 | 3 | 1.5 | 4.5 | 208.3 | 150.4 | 18.4 | 0.145341 | 200 | 160 | 186.2 | 149 | 200 mmø-160 mmø | 0.000773333 | AWADUKT PP reduction DN 200/160 | 4007360343590 | 12477911002 | 0.8985
282864 | 143 | 153 | 4 | 2 | 6 | 260.3 | 187.8 | 23 | 0.232497 | 250 | 200 | 232.8 | 186.2 | 250 mmø-200 mmø | 0.00158097 | AWADUKT PP reduction DN 250/200 | 4007360343606 | 12478011002 | 1.719
282868 | 150 | 162 | 5 | 2.5 | 7 | 327.3 | 232.8 | 31.7 | 0.324414 | 315 | 250 | 293.4 | 232.8 | 315 mmø-250 mmø | 0.00260838 | AWADUKT PP reduction DN 315/250 | 4007360410698 | 12478111002 | 2.995
282872 | 223 | 242 | 10 | 5 | 9 | 450 | 292.8 | 40.7 | 0.562461 | 400 | 315 | 372.6 | 293.4 | 400 mmø-315 mmø | 0.0059292 | AWADUKT PP reduction DN 400/315 | 4007360345969 | 12373231003 | 4.924
282876 | 263 | 288 | 14 | 7 | 11 | 550 | 372.1 | 48.3 | 0.812234 | 500 | 400 | 465.8 | 372.6 | 500 mmø-400 mmø | 0.0110476 | AWADUKT PP reduction DN 500/400 | 4007360345952 | 12346261003 | 9.855
282880 | 315 | 341 | 15 | 7.5 | 11 | 700 | 466.1 | 61.9 | 1.24279 | 630 | 500 | 586.8 | 465.8 | 630 mmø-500 mmø | 0.0207494 | AWADUKT PP reduction DN 630/500 | 4007360375096 | 14115521005 | 18.19
283465 | 86.4 | 92.9 | 2.5 | 1.25 | 4 | 168 | 101 | 24.3 | 0.0965827 | 160 | 110 | 149 | 102.4 | 160 mmø-110 mmø | 0.000489684 | AWADUKT PP reduction DN 160/110 | 4007360242305 | 12475211001 | 0.528

# IfcFlowFitting: AWADUKT PP Union DSM:Blue (8)
In: Ground floor
Type - Material: AWADUKT PP SN10 Blue
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union DSM; T1: APP DSM; T2: APP SN10 Double Socket
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Blue; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Blue
Type - Materials and Finishes - APP: AWADUKT PP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP Union DSM:Blue; sets with these values: 2
Other - IsCustom: no; Type: Blue; 110-630: yes; 710: no; 800: no; Family: AWADUKT PP Union DSM; Family and Type: AWADUKT PP Union DSM: Blue; Type Id: 215266
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Work Plane: Level : Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union DSM:Blue:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
256939 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531 | AWADUKT PP BLUE double socket DN 110 | 4007360502362 | 12475511016 | 0.275
256941 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587 | AWADUKT PP BLUE double socket DN 200 | 4007360640118 | 11054761016 | 1.017
256943 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022 | AWADUKT PP BLUE double socket DN 250 | 4007360635213 | 11054751016 | 2.187
256945 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379 | AWADUKT PP BLUE double socket DN 315 | 4007360639570 | 11054741016 | 3.693
256947 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004 | AWADUKT PP BLUE double socket DN 400 | 4007360617301 | 11054731016 | 7.134
256949 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193 | AWADUKT PP BLUE double socket DN 500 | 4007360578411 | 13156061056 | 10.544
256951 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891 | AWADUKT PP BLUE double socket DN 630 | 4059757634446 | 11154711016 | 16.028
256953 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114 | AWADUKT PP BLUE double socket DN 160 | 4007360640170 | 11054771016 | 0.58

# IfcFlowFitting: AWADUKT PP Union DSM:Blue No PID (180)
In: Ground floor
Type - Material: AWADUKT PP SN10 Blue
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union DSM; T1: APP DSM; T2: APP SN10 Double Socket
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Blue No PID
Type - Materials and Finishes - APP: AWADUKT PP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP Union DSM:Blue No PID; sets with these values: 2
Other - IsCustom: no; 110-630: yes; 710: no; 800: no; Family: AWADUKT PP Union DSM; Family and Type: AWADUKT PP Union DSM: Blue No PID; Type: Blue No PID; Type Id: 211450
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Identity Data - Sorting: 0; Description long: -; GTIN: -; PID: -; Weight: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union DSM:Blue No PID:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3)
229368 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
229722 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
229779 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
229843 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
229891 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
229935 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
230003 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230005 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230144 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230146 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230253 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
230257 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
230261 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
230265 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
230269 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
230273 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
230278 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230280 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230284 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230286 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230360 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
230364 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
230368 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
230372 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
230376 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
230380 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
230385 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230387 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230391 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230393 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230456 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
230460 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
230464 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
230468 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
230472 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
230476 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
230481 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230483 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230487 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230489 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
230668 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
230901 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
230912 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
230923 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
230936 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
230947 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
230958 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
230969 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
231257 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
231259 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
231281 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
231283 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
231304 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
231306 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
231323 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
231325 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
231400 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
231404 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
231408 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
231412 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
231416 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
231420 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
231424 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
231788 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
231792 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
231796 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
231800 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
231804 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
231866 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
231870 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
231874 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
231878 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
231989 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
231991 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
231996 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
231998 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
232002 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232004 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
232008 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232010 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
232120 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232124 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232128 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232136 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232138 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232140 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232142 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232144 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232146 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232206 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232210 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232218 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232220 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232222 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232224 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232264 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232272 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232274 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232447 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
232451 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
232455 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
232459 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232463 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232467 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232471 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232496 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
232500 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
232504 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232508 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232512 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232516 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232521 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
232525 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232529 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232533 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232537 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232542 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
232546 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232550 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232554 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232575 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
232579 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232583 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232600 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
232604 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
232617 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
242065 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
250900 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
250902 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
250907 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
250909 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
250914 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
250916 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
250919 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
250921 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
250932 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
250934 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
250939 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
250941 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
250946 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
250948 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
250951 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
250953 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
250963 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
250965 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
250971 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
250973 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
250979 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
250981 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
250985 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
250987 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
250993 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
250995 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
251001 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251003 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
251009 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251011 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
251015 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251017 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
251023 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251025 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
251031 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251033 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
251037 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251039 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
251045 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251047 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251051 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251053 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251057 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251059 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251061 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
251063 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
257142 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
281362 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
281375 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
281386 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
281399 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
281410 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
283563 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114

# IfcFlowFitting: AWADUKT PP Union DSM:Orange (8)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union DSM; T1: APP DSM; T2: APP SN10 Double Socket
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Orange; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP Union DSM:Orange; sets with these values: 2
Other - IsCustom: no; 110-630: yes; 710: no; 800: no; Family: AWADUKT PP Union DSM; Type: Orange; Family and Type: AWADUKT PP Union DSM: Orange; Type Id: 215216
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Work Plane: Level : Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union DSM:Orange:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
282844 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531 | AWADUKT PP double socket DN 110 | 4007360242336 | 12475511001 | 0.275
282846 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587 | AWADUKT PP double socket DN 200 | 4007360640101 | 11054761001 | 1.017
282848 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022 | AWADUKT PP double socket DN 250 | 4007360634698 | 11054751001 | 2.168
282850 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379 | AWADUKT PP double socket DN 315 | 4007360639563 | 11054741001 | 3.688
282852 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004 | AWADUKT PP double socket DN 400 | 4007360617073 | 11054731001 | 7.134
282854 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193 | AWADUKT PP double socket DN 500 | 4007360577728 | 13156061002 | 10.544
282856 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891 | AWADUKT PP double socket DN 630 | 4059757634439 | 11154711001 | 16.028
282858 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114 | AWADUKT PP double socket DN 160 | 4007360640163 | 11054771001 | 0.58

# IfcFlowFitting: AWADUKT PP Union DSM:Orange No PID (180)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union DSM; T1: APP DSM; T2: APP SN10 Double Socket
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange No PID
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_DistributionFlowElementCommon - Reference: AWADUKT PP Union DSM:Orange No PID; sets with these values: 2
Other - IsCustom: no; 110-630: yes; 710: no; 800: no; Family: AWADUKT PP Union DSM; Family and Type: AWADUKT PP Union DSM: Orange No PID; Type: Orange No PID; Type Id: 211448
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Identity Data - Sorting: 0; Description long: -; GTIN: -; PID: -; Weight: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union DSM:Orange No PID:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3)
282301 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282305 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282309 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282313 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282317 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282321 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282326 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282328 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282332 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282334 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282337 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282341 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282345 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282349 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282353 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282357 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282362 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282364 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282368 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282370 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282373 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282377 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282381 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282385 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282389 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282393 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282398 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282400 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282404 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282406 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282409 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282413 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282417 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282421 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282425 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282429 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282434 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282436 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282440 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282442 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282445 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282449 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282453 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282457 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282461 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282465 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282469 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282473 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282476 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282478 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282480 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282482 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282484 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282486 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282488 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282490 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282493 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282497 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
