Properties of the parts of a building model (IFC4), part 3 of 3

# IfcPipeFitting: AWADUKT PP Union DSM:Blue No PID (180)
Name (AWADUKT PP Union DSM:Blue No PID:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3)
251009 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251011 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
251015 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251017 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
251023 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251025 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
251031 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251033 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
251037 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251039 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
251045 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251047 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251051 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251053 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
251057 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
251059 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
251061 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
251063 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
257142 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
281362 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
281375 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
281386 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
281399 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
281410 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
283563 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114

# IfcPipeFitting: AWADUKT PP Union DSM:Orange (8)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union DSM; T1: APP DSM; T2: APP SN10 Double Socket
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Orange; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: AWADUKT PP Union DSM:Orange; sets with these values: 2
Other - IsCustom: no; 110-630: yes; 710: no; 800: no; Family: AWADUKT PP Union DSM; Type: Orange; Family and Type: AWADUKT PP Union DSM: Orange; Type Id: 215216
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Work Plane: Level : Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union DSM:Orange:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
282844 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531 | AWADUKT PP double socket DN 110 | 4007360242336 | 12475511001 | 0.275
282846 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587 | AWADUKT PP double socket DN 200 | 4007360640101 | 11054761001 | 1.017
282848 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022 | AWADUKT PP double socket DN 250 | 4007360634698 | 11054751001 | 2.168
282850 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379 | AWADUKT PP double socket DN 315 | 4007360639563 | 11054741001 | 3.688
282852 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004 | AWADUKT PP double socket DN 400 | 4007360617073 | 11054731001 | 7.134
282854 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193 | AWADUKT PP double socket DN 500 | 4007360577728 | 13156061002 | 10.544
282856 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891 | AWADUKT PP double socket DN 630 | 4059757634439 | 11154711001 | 16.028
282858 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114 | AWADUKT PP double socket DN 160 | 4007360640163 | 11054771001 | 0.58

# IfcPipeFitting: AWADUKT PP Union DSM:Orange No PID (180)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union DSM; T1: APP DSM; T2: APP SN10 Double Socket
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange No PID
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: AWADUKT PP Union DSM:Orange No PID; sets with these values: 2
Other - IsCustom: no; 110-630: yes; 710: no; 800: no; Family: AWADUKT PP Union DSM; Family and Type: AWADUKT PP Union DSM: Orange No PID; Type: Orange No PID; Type Id: 211448
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Identity Data - Sorting: 0; Description long: -; GTIN: -; PID: -; Weight: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union DSM:Orange No PID:...) | S2 (mm) | Z1 (mm) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3)
282301 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282305 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282309 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282313 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282317 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282321 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282326 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282328 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282332 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282334 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282337 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282341 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282345 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282349 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282353 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282357 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282362 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282364 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282368 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282370 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282373 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282377 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282381 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282385 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282389 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282393 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282398 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282400 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282404 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282406 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282409 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282413 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282417 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282421 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282425 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282429 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282434 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282436 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282440 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282442 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282445 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282449 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282453 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282457 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282461 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282465 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282469 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282473 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282476 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282478 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282480 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282482 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282484 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282486 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282488 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282490 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282493 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282497 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282501 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282505 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282509 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282513 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282517 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282521 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282525 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282529 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282533 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282537 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282541 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282545 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282549 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282553 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282556 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282558 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282560 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282562 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282564 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282566 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282568 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282570 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282573 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282577 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282581 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282584 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282586 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282588 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282590 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282592 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282594 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282597 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282601 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282604 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282606 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282608 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282610 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282613 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282616 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282618 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282621 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282625 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282629 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282633 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282637 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282641 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282645 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282649 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282653 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282657 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282661 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282665 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282669 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282673 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282677 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282681 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282685 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282689 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282693 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282697 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282701 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282705 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282709 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282713 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282717 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282721 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282725 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282729 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282733 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282736 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282738 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282740 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282742 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282744 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282746 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282748 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282750 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282752 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282754 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282756 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282758 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282760 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282762 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282764 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282766 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282768 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282770 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282772 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282774 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282776 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282778 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282780 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282782 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282784 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282786 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282788 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282790 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282792 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282794 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282796 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282798 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282800 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282802 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282804 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282806 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282808 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282810 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282812 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282814 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282816 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282818 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282820 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
282822 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282824 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114
282826 | 4 | 2 | 3.27163 | 110 | 102.4 | 110 mmø-110 mmø | 0.000363531
282861 | 4.5 | 2.25 | 3.36538 | 200 | 186.2 | 200 mmø-200 mmø | 0.00122587
282865 | 6 | 3 | 3.45469 | 250 | 232.8 | 250 mmø-250 mmø | 0.00264022
282869 | 7 | 3.5 | 3.56282 | 315 | 293.4 | 315 mmø-315 mmø | 0.00426379
282873 | 9 | 4.5 | 3.7654 | 400 | 372.6 | 400 mmø-400 mmø | 0.00813004
282877 | 11 | 5.5 | 4.00814 | 500 | 465.8 | 500 mmø-500 mmø | 0.0124193
282881 | 11 | 5.5 | 4.35498 | 630 | 586.8 | 630 mmø-630 mmø | 0.0207891
283466 | 4 | 2 | 3.31675 | 160 | 149 | 160 mmø-160 mmø | 0.000721114

# IfcPipeFitting: AWADUKT PP Union USM:Blue (8)
In: Ground floor
Type - Material: AWADUKT PP SN10 Blue
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union USM; T1: APP SN10 Union USM
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Blue; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Blue
Type - Materials and Finishes - APP: AWADUKT PP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: AWADUKT PP Union USM:Blue; sets with these values: 2
Other - IsCustom: no; Type: Blue; Family: AWADUKT PP Union USM; Family and Type: AWADUKT PP Union USM: Blue; Type Id: 228474
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Work Plane: Level : Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union USM:Blue:...) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
251344 | 0.0614212 | 110 | 110 mmø-110 mmø | 0.00026437 | AWADUKT PP BLUE sleeve coupler DN 110 | 4007360502355 | 12475311016 | 0.27
251741 | 0.152137 | 200 | 200 mmø-200 mmø | 0.00104508 | AWADUKT PP BLUE sleeve coupler DN 200 | 4007360583736 | 11043061016 | 0.837
251750 | 0.224865 | 250 | 250 mmø-250 mmø | 0.00175919 | AWADUKT PP BLUE sleeve coupler DN 250 | 4007360576592 | 11043071016 | 1.857
251759 | 0.343841 | 315 | 315 mmø-315 mmø | 0.00393191 | AWADUKT PP BLUE sleeve coupler DN 315 | 4007360577704 | 11043081016 | 3.163
251768 | 0.546754 | 400 | 400 mmø-400 mmø | 0.00805606 | AWADUKT PP BLUE sleeve coupler DN 400 | 4007360617332 | 11053831016 | 6.049
251777 | 0.77995 | 500 | 500 mmø-500 mmø | 0.0119813 | AWADUKT PP BLUE sleeve coupler DN 500 | 4007360578442 | 14075191056 | 10.243
251786 | 1.08516 | 630 | 630 mmø-630 mmø | 0.0173689 | AWADUKT PP BLUE sleeve coupler DN 630 | 4059757634460 | 11154811016 | 15.36
251855 | 0.104705 | 160 | 160 mmø-160 mmø | 0.000569379 | AWADUKT PP BLUE sleeve coupler DN 160 | 4007360576585 | 11043051016 | 0.494

# IfcPipeFitting: AWADUKT PP Union USM:Orange (8)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP Union USM; T1: APP SN10 Union USM
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Orange; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: AWADUKT PP Union USM:Orange; sets with these values: 2
Other - IsCustom: no; Family: AWADUKT PP Union USM; Type: Orange; Family and Type: AWADUKT PP Union USM: Orange; Type Id: 228472
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Work Plane: Level : Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP Union USM:Orange:...) | Area (m2) | DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
282828 | 0.0614212 | 110 | 110 mmø-110 mmø | 0.00026437 | AWADUKT PP sleeve coupler DN 110 | 4007360242312 | 12475311001 | 0.27
282830 | 0.152137 | 200 | 200 mmø-200 mmø | 0.00104508 | AWADUKT PP sleeve coupler DN 200 | 4007360583729 | 11043061001 | 0.837
282832 | 0.224865 | 250 | 250 mmø-250 mmø | 0.00175919 | AWADUKT PP sleeve coupler DN 250 | 4007360577087 | 11043071001 | 1.857
282834 | 0.343841 | 315 | 315 mmø-315 mmø | 0.00393191 | AWADUKT PP sleeve coupler DN 315 | 4007360577094 | 11043081001 | 3.163
282836 | 0.546754 | 400 | 400 mmø-400 mmø | 0.00805606 | AWADUKT PP sleeve coupler DN 400 | 4007360617349 | 11053831001 | 6.049
282838 | 0.77995 | 500 | 500 mmø-500 mmø | 0.0119813 | AWADUKT PP sleeve coupler DN 500 | 4007360577742 | 14075191001 | 10.243
282840 | 1.08516 | 630 | 630 mmø-630 mmø | 0.0173689 | AWADUKT PP sleeve coupler DN 630 | 4059757634453 | 11154811001 | 15.5
282842 | 0.104705 | 160 | 160 mmø-160 mmø | 0.000569379 | AWADUKT PP sleeve coupler DN 160 | 4007360577070 | 11043051001 | 0.494

# IfcPipeSegment: Pipe Types:AWADUKT NevoPP SN10 (18)
In: Ground floor
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Manufacturer: REHAU; Model: AWADUKT PP SN10; Type Name: AWADUKT NevoPP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:AWADUKT NevoPP SN10; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: AWADUKT NevoPP SN10; Type: AWADUKT NevoPP SN10; Type Id: 283008
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Ground floor; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Mechanical - System Type: Sanitary; Material: AWADUKT PP SN10; Pipe Segment: AWADUKT PP SN10 - 110-800; Schedule/Type: 110-800; Connection Type: Generic; Roughness: 0.034 mm; Segment Description: 110-800; System Classification: Sanitary
Mechanical - Flow - Fixture Units: 0; Section: 1
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:AWADUKT NevoPP SN10:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Length (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
282884 | -51.2 | -55 | 51.2 | 55 | 102.4 | 6000 | 110 | 110 mmø | 3.8 | 2.07345 | Sanitary 67 | 0.000332031
282886 | -74.5 | -80 | 74.5 | 80 | 149 | 6000 | 160 | 160 mmø | 5.5 | 3.01593 | Sanitary 68 | 0.000228188
282888 | -93.1 | -100 | 93.1 | 100 | 186.2 | 6000 | 200 | 200 mmø | 6.9 | 3.76991 | Sanitary 69 | 0.000182599
282890 | -116.4 | -125 | 116.4 | 125 | 232.8 | 6000 | 250 | 250 mmø | 8.6 | 4.71239 | Sanitary 70 | 0.000146048
282892 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 6000 | 315 | 315 mmø | 10.8 | 5.93761 | Sanitary 71 | 0.000115883
282894 | -186.3 | -200 | 186.3 | 200 | 372.6 | 6000 | 400 | 400 mmø | 13.7 | 7.53982 | Sanitary 72 | 0.0000912507
282896 | -51.2 | -55 | 51.2 | 55 | 102.4 | 3000 | 110 | 110 mmø | 3.8 | 1.03673 | Sanitary 73 | 0.000332031
282898 | -74.5 | -80 | 74.5 | 80 | 149 | 3000 | 160 | 160 mmø | 5.5 | 1.50796 | Sanitary 74 | 0.000228188
282900 | -93.1 | -100 | 93.1 | 100 | 186.2 | 3000 | 200 | 200 mmø | 6.9 | 1.88496 | Sanitary 75 | 0.000182599
282902 | -116.4 | -125 | 116.4 | 125 | 232.8 | 3000 | 250 | 250 mmø | 8.6 | 2.35619 | Sanitary 76 | 0.000146048
282904 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 3000 | 315 | 315 mmø | 10.8 | 2.96881 | Sanitary 77 | 0.000115883
282906 | -186.3 | -200 | 186.3 | 200 | 372.6 | 3000 | 400 | 400 mmø | 13.7 | 3.76991 | Sanitary 78 | 0.0000912507
282908 | -51.2 | -55 | 51.2 | 55 | 102.4 | 1000 | 110 | 110 mmø | 3.8 | 0.345575 | Sanitary 79 | 0.000332031
282910 | -74.5 | -80 | 74.5 | 80 | 149 | 1000 | 160 | 160 mmø | 5.5 | 0.502655 | Sanitary 80 | 0.000228188
282912 | -93.1 | -100 | 93.1 | 100 | 186.2 | 1000 | 200 | 200 mmø | 6.9 | 0.628319 | Sanitary 81 | 0.000182599
282914 | -116.4 | -125 | 116.4 | 125 | 232.8 | 1000 | 250 | 250 mmø | 8.6 | 0.785398 | Sanitary 82 | 0.000146048
282916 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 1000 | 315 | 315 mmø | 10.8 | 0.989602 | Sanitary 83 | 0.000115883
282918 | -186.3 | -200 | 186.3 | 200 | 372.6 | 1000 | 400 | 400 mmø | 13.7 | 1.25664 | Sanitary 84 | 0.0000912507

# IfcPipeSegment: Pipe Types:AWADUKT NevoPP SN10 Blue (18)
In: Ground floor
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Manufacturer: REHAU; Model: AWADUKT PP SN10; Type Name: AWADUKT NevoPP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:AWADUKT NevoPP SN10 Blue; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: AWADUKT NevoPP SN10 Blue; Type: AWADUKT NevoPP SN10 Blue; Type Id: 281983
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Ground floor; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Mechanical - System Type: Sanitary; Connection Type: Generic; Material: AWADUKT NevoPP SN10 Blue; Pipe Segment: AWADUKT NevoPP SN10 Blue - 110-400; Roughness: 0.034 mm; Schedule/Type: 110-400; Segment Description: 110-400; System Classification: Sanitary
Mechanical - Flow - Fixture Units: 0; Section: 1
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:AWADUKT NevoPP SN10 Blue:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Length (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
281705 | -51.2 | -55 | 51.2 | 55 | 102.4 | 6000 | 110 | 110 mmø | 3.8 | 2.07345 | Sanitary 25 | 0.000332031
281707 | -74.5 | -80 | 74.5 | 80 | 149 | 6000 | 160 | 160 mmø | 5.5 | 3.01593 | Sanitary 26 | 0.000228188
281709 | -93.1 | -100 | 93.1 | 100 | 186.2 | 6000 | 200 | 200 mmø | 6.9 | 3.76991 | Sanitary 27 | 0.000182599
281711 | -116.4 | -125 | 116.4 | 125 | 232.8 | 6000 | 250 | 250 mmø | 8.6 | 4.71239 | Sanitary 28 | 0.000146048
281713 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 6000 | 315 | 315 mmø | 10.8 | 5.93761 | Sanitary 29 | 0.000115883
281715 | -186.3 | -200 | 186.3 | 200 | 372.6 | 6000 | 400 | 400 mmø | 13.7 | 7.53982 | Sanitary 30 | 0.0000912507
281808 | -51.2 | -55 | 51.2 | 55 | 102.4 | 3000 | 110 | 110 mmø | 3.8 | 1.03673 | Sanitary 33 | 0.000332031
281810 | -74.5 | -80 | 74.5 | 80 | 149 | 3000 | 160 | 160 mmø | 5.5 | 1.50796 | Sanitary 34 | 0.000228188
281812 | -93.1 | -100 | 93.1 | 100 | 186.2 | 3000 | 200 | 200 mmø | 6.9 | 1.88496 | Sanitary 35 | 0.000182599
281814 | -116.4 | -125 | 116.4 | 125 | 232.8 | 3000 | 250 | 250 mmø | 8.6 | 2.35619 | Sanitary 36 | 0.000146048
281816 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 3000 | 315 | 315 mmø | 10.8 | 2.96881 | Sanitary 37 | 0.000115883
281818 | -186.3 | -200 | 186.3 | 200 | 372.6 | 3000 | 400 | 400 mmø | 13.7 | 3.76991 | Sanitary 38 | 0.0000912507
281861 | -51.2 | -55 | 51.2 | 55 | 102.4 | 1000 | 110 | 110 mmø | 3.8 | 0.345575 | Sanitary 41 | 0.000332031
281863 | -74.5 | -80 | 74.5 | 80 | 149 | 1000 | 160 | 160 mmø | 5.5 | 0.502655 | Sanitary 42 | 0.000228188
281865 | -93.1 | -100 | 93.1 | 100 | 186.2 | 1000 | 200 | 200 mmø | 6.9 | 0.628319 | Sanitary 43 | 0.000182599
281867 | -116.4 | -125 | 116.4 | 125 | 232.8 | 1000 | 250 | 250 mmø | 8.6 | 0.785398 | Sanitary 44 | 0.000146048
281869 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 1000 | 315 | 315 mmø | 10.8 | 0.989602 | Sanitary 45 | 0.000115883
281871 | -186.3 | -200 | 186.3 | 200 | 372.6 | 1000 | 400 | 400 mmø | 13.7 | 1.25664 | Sanitary 46 | 0.0000912507

# IfcPipeSegment: Pipe Types:AWADUKT PP SN10 (24)
In: Ground floor
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Manufacturer: REHAU; Model: AWADUKT PP SN10; Type Name: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:AWADUKT PP SN10; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: AWADUKT PP SN10; Type: AWADUKT PP SN10; Type Id: 186019
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Ground floor; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Mechanical - System Type: Sanitary; Connection Type: Generic; Material: AWADUKT PP SN10; Pipe Segment: AWADUKT PP SN10 - 110-800; Roughness: 0.034 mm; Schedule/Type: 110-800; Segment Description: 110-800; System Classification: Sanitary
Mechanical - Flow - Fixture Units: 0; Section: 1
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:AWADUKT PP SN10:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Length (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
282252 | -51.2 | -55 | 51.2 | 55 | 102.4 | 1000 | 110 | 110 mmø | 3.8 | 0.345575 | Sanitary 31 | 0.000332031
282254 | -51.2 | -55 | 51.2 | 55 | 102.4 | 3000 | 110 | 110 mmø | 3.8 | 1.03673 | Sanitary 32 | 0.000332031
282256 | -51.2 | -55 | 51.2 | 55 | 102.4 | 6000 | 110 | 110 mmø | 3.8 | 2.07345 | Sanitary 39 | 0.000332031
282258 | -74.5 | -80 | 74.5 | 80 | 149 | 1000 | 160 | 160 mmø | 5.5 | 0.502655 | Sanitary 40 | 0.000228188
282260 | -74.5 | -80 | 74.5 | 80 | 149 | 3000 | 160 | 160 mmø | 5.5 | 1.50796 | Sanitary 47 | 0.000228188
282262 | -74.5 | -80 | 74.5 | 80 | 149 | 6000 | 160 | 160 mmø | 5.5 | 3.01593 | Sanitary 48 | 0.000228188
282264 | -93.1 | -100 | 93.1 | 100 | 186.2 | 1000 | 200 | 200 mmø | 6.9 | 0.628319 | Sanitary 49 | 0.000182599
282266 | -93.1 | -100 | 93.1 | 100 | 186.2 | 3000 | 200 | 200 mmø | 6.9 | 1.88496 | Sanitary 50 | 0.000182599
282268 | -93.1 | -100 | 93.1 | 100 | 186.2 | 6000 | 200 | 200 mmø | 6.9 | 3.76991 | Sanitary 51 | 0.000182599
282270 | -116.4 | -125 | 116.4 | 125 | 232.8 | 1000 | 250 | 250 mmø | 8.6 | 0.785398 | Sanitary 52 | 0.000146048
282272 | -116.4 | -125 | 116.4 | 125 | 232.8 | 3000 | 250 | 250 mmø | 8.6 | 2.35619 | Sanitary 53 | 0.000146048
282274 | -116.4 | -125 | 116.4 | 125 | 232.8 | 6000 | 250 | 250 mmø | 8.6 | 4.71239 | Sanitary 54 | 0.000146048
282276 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 1000 | 315 | 315 mmø | 10.8 | 0.989602 | Sanitary 55 | 0.000115883
282278 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 3000 | 315 | 315 mmø | 10.8 | 2.96881 | Sanitary 56 | 0.000115883
282280 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 6000 | 315 | 315 mmø | 10.8 | 5.93761 | Sanitary 57 | 0.000115883
282282 | -186.3 | -200 | 186.3 | 200 | 372.6 | 1000 | 400 | 400 mmø | 13.7 | 1.25664 | Sanitary 58 | 0.0000912507
282284 | -186.3 | -200 | 186.3 | 200 | 372.6 | 3000 | 400 | 400 mmø | 13.7 | 3.76991 | Sanitary 59 | 0.0000912507
282286 | -186.3 | -200 | 186.3 | 200 | 372.6 | 6000 | 400 | 400 mmø | 13.7 | 7.53982 | Sanitary 60 | 0.0000912507
282288 | -232.9 | -250 | 232.9 | 250 | 465.8 | 1000 | 500 | 500 mmø | 17.1 | 1.5708 | Sanitary 61 | 0.0000729927
282290 | -232.9 | -250 | 232.9 | 250 | 465.8 | 3000 | 500 | 500 mmø | 17.1 | 4.71239 | Sanitary 62 | 0.0000729927
282292 | -232.9 | -250 | 232.9 | 250 | 465.8 | 6000 | 500 | 500 mmø | 17.1 | 9.42478 | Sanitary 63 | 0.0000729927
282294 | -293.4 | -315 | 293.4 | 315 | 586.8 | 1000 | 630 | 630 mmø | 21.6 | 1.9792 | Sanitary 64 | 0.0000579414
282296 | -293.4 | -315 | 293.4 | 315 | 586.8 | 3000 | 630 | 630 mmø | 21.6 | 5.93761 | Sanitary 65 | 0.0000579414
282298 | -293.4 | -315 | 293.4 | 315 | 586.8 | 6000 | 630 | 630 mmø | 21.6 | 11.8752 | Sanitary 66 | 0.0000579414

# IfcPipeSegment: Pipe Types:AWADUKT PP SN10 Blue (24)
In: Ground floor
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Manufacturer: REHAU; Model: AWADUKT PP SN10; Type Name: AWADUKT PP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:AWADUKT PP SN10 Blue; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: AWADUKT PP SN10 Blue; Type: AWADUKT PP SN10 Blue; Type Id: 196900
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Ground floor; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Mechanical - Connection Type: Generic; Material: AWADUKT PP SN10 Blue; Pipe Segment: AWADUKT PP SN10 Blue - 110-630; Roughness: 0.034 mm; Schedule/Type: 110-630; Segment Description: 110-800; System Classification: Sanitary; System Type: Sanitary
Mechanical - Flow - Fixture Units: 0; Section: 1
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:AWADUKT PP SN10 Blue:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Length (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
228974 | -51.2 | -55 | 51.2 | 55 | 102.4 | 1000 | 110 | 110 mmø | 3.8 | 0.345575 | Sanitary 1 | 0.000332031
229055 | -51.2 | -55 | 51.2 | 55 | 102.4 | 3000 | 110 | 110 mmø | 3.8 | 1.03673 | Sanitary 2 | 0.000332031
229115 | -51.2 | -55 | 51.2 | 55 | 102.4 | 6000 | 110 | 110 mmø | 3.8 | 2.07345 | Sanitary 3 | 0.000332031
229158 | -74.5 | -80 | 74.5 | 80 | 149 | 1000 | 160 | 160 mmø | 5.5 | 0.502655 | Sanitary 4 | 0.000228188
229160 | -74.5 | -80 | 74.5 | 80 | 149 | 3000 | 160 | 160 mmø | 5.5 | 1.50796 | Sanitary 5 | 0.000228188
229162 | -74.5 | -80 | 74.5 | 80 | 149 | 6000 | 160 | 160 mmø | 5.5 | 3.01593 | Sanitary 6 | 0.000228188
229196 | -93.1 | -100 | 93.1 | 100 | 186.2 | 1000 | 200 | 200 mmø | 6.9 | 0.628319 | Sanitary 7 | 0.000182599
229198 | -93.1 | -100 | 93.1 | 100 | 186.2 | 3000 | 200 | 200 mmø | 6.9 | 1.88496 | Sanitary 8 | 0.000182599
229200 | -93.1 | -100 | 93.1 | 100 | 186.2 | 6000 | 200 | 200 mmø | 6.9 | 3.76991 | Sanitary 9 | 0.000182599
229207 | -116.4 | -125 | 116.4 | 125 | 232.8 | 1000 | 250 | 250 mmø | 8.6 | 0.785398 | Sanitary 10 | 0.000146048
229209 | -116.4 | -125 | 116.4 | 125 | 232.8 | 3000 | 250 | 250 mmø | 8.6 | 2.35619 | Sanitary 11 | 0.000146048
229211 | -116.4 | -125 | 116.4 | 125 | 232.8 | 6000 | 250 | 250 mmø | 8.6 | 4.71239 | Sanitary 12 | 0.000146048
229218 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 1000 | 315 | 315 mmø | 10.8 | 0.989602 | Sanitary 13 | 0.000115883
229220 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 3000 | 315 | 315 mmø | 10.8 | 2.96881 | Sanitary 14 | 0.000115883
229222 | -146.7 | -157.5 | 146.7 | 157.5 | 293.4 | 6000 | 315 | 315 mmø | 10.8 | 5.93761 | Sanitary 15 | 0.000115883
229229 | -186.3 | -200 | 186.3 | 200 | 372.6 | 1000 | 400 | 400 mmø | 13.7 | 1.25664 | Sanitary 16 | 0.0000912507
229231 | -186.3 | -200 | 186.3 | 200 | 372.6 | 3000 | 400 | 400 mmø | 13.7 | 3.76991 | Sanitary 17 | 0.0000912507
229233 | -186.3 | -200 | 186.3 | 200 | 372.6 | 6000 | 400 | 400 mmø | 13.7 | 7.53982 | Sanitary 18 | 0.0000912507
229261 | -232.9 | -250 | 232.9 | 250 | 465.8 | 1000 | 500 | 500 mmø | 17.1 | 1.5708 | Sanitary 19 | 0.0000729927
229263 | -232.9 | -250 | 232.9 | 250 | 465.8 | 3000 | 500 | 500 mmø | 17.1 | 4.71239 | Sanitary 20 | 0.0000729927
229265 | -232.9 | -250 | 232.9 | 250 | 465.8 | 6000 | 500 | 500 mmø | 17.1 | 9.42478 | Sanitary 21 | 0.0000729927
229272 | -293.4 | -315 | 293.4 | 315 | 586.8 | 1000 | 630 | 630 mmø | 21.6 | 1.9792 | Sanitary 22 | 0.0000579414
229274 | -293.4 | -315 | 293.4 | 315 | 586.8 | 3000 | 630 | 630 mmø | 21.6 | 5.93761 | Sanitary 23 | 0.0000579414
229276 | -293.4 | -315 | 293.4 | 315 | 586.8 | 6000 | 630 | 630 mmø | 21.6 | 11.8752 | Sanitary 24 | 0.0000579414
