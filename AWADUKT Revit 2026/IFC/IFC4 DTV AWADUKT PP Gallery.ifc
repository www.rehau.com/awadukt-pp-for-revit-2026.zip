Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [ContentGUID: 5014fbbf-79f6-451e-976c-230a218d2359, VersionGUID: f731394a-191e-4d35-9f4f-6849b33217f7, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [BuildingService]
File name: AWADUKT PP Gallery.ifc
Time: 2025-12-05T11:58:17+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENG) - 26.4.0.32

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Ground floor
LongName: Ground floor; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level:Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground floor; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: AWASCHACHT 1000 Cone:AWASCHACHT 1000 Cone (8)
In: Ground floor
Type - Material: <Unnamed>, AWADUKT PP SN10
Type - Other - Category: Generic Models; Family Name: AWASCHACHT 1000 Cone
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.00.00; PID: 11904881001; Type Name: AWASCHACHT 1000 Cone
Type - Materials and Finishes - Mat. APP: AWADUKT PP SN10
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: AWASCHACHT 1000 Cone:AWASCHACHT 1000 Cone
Pset_EnvironmentalImpactIndicators - Reference: AWASCHACHT 1000 Cone:AWASCHACHT 1000 Cone
Other - Family: AWASCHACHT 1000 Cone; Family and Type: AWASCHACHT 1000 Cone: AWASCHACHT 1000 Cone; Type: AWASCHACHT 1000 Cone; Type Id: 376575
Constraints - Moves With Nearby Elements: no; Elevation from Level: -778 mm; Offset from Host: -778 mm
Dimensions - Area: 4.18601 m2; Volume: 0.116538 m3
Phasing - Phase Created: New Construction
Name (AWASCHACHT 1000 Cone:AWASCHACHT 1000 Cone:...)
403061
403062
403063
403064
403065
403066
403067
403068

# IfcBuildingElementProxy: AWASCHACHT 800 Cone:AWASCHACHT 800 Cone (8)
In: Ground floor
Type - Material: <Unnamed>, AWADUKT PP SN10
Type - Other - Category: Generic Models; Family Name: AWASCHACHT 800 Cone
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.00.00; Type Name: AWASCHACHT 800 Cone
Type - Materials and Finishes - Mat. APP: AWADUKT PP SN10
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: AWASCHACHT 800 Cone:AWASCHACHT 800 Cone
Pset_EnvironmentalImpactIndicators - Reference: AWASCHACHT 800 Cone:AWASCHACHT 800 Cone
Other - Family: AWASCHACHT 800 Cone; Family and Type: AWASCHACHT 800 Cone: AWASCHACHT 800 Cone; Type: AWASCHACHT 800 Cone; Type Id: 376576
Constraints - Elevation from Level: 2295 mm; Moves With Nearby Elements: no; Offset from Host: 2295 mm
Dimensions - Area: 3.45951 m2; Volume: 0.123083 m3
Phasing - Phase Created: New Construction
Name (AWASCHACHT 800 Cone:AWASCHACHT 800 Cone:...)
376931
376932
376933
376934
377197 | Constraints - Host: Level : Ground floor
377198 | Constraints - Host: Level : Ground floor
377199 | Constraints - Host: Level : Ground floor
377200 | Constraints - Host: Level : Ground floor

# IfcBuildingElementProxy: AWASCHACHT1:DN 600 (8)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Generic Models; Cone height: 200 mm; DN/Di Chamber: 600 mm; Do Chamber: 680 mm; Family Name: AWASCHACHT1; Z: 460 mm
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.00.00; Type Name: DN 600
Type - Materials and Finishes - Mat. APP: AWADUKT PP SN10
Type - Visibility - AWASCHACHT Cone Type: AWASCHACHT Cone : DN 600
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: AWASCHACHT1:DN 600
Pset_EnvironmentalImpactIndicators - Reference: AWASCHACHT1:DN 600
Other - Di2: 180 mm; Di3: 180 mm; Di4: 180 mm; Family: AWASCHACHT1; Family and Type: AWASCHACHT1: DN 600; Type: DN 600; Type Id: 394387; Z 1: 315 mm; Z 2: 290 mm; Z 3: 290 mm; Z 4: 290 mm
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Offset from Host: 0 mm; Work Plane: Level : Ground floor
Dimensions - Cone Rotation: 90 deg; Di1: 230 mm; DN1: 250 mm; DN2: 200 mm; DN3: 200 mm; DN4: 200 mm
Phasing - Phase Created: New Construction
Visibility - Connection DN2: yes
Name (AWASCHACHT1:DN 600:...) | Angle DN2 (deg) = Angle DN4 (deg) | Area (m2) | Depth Con. DN1 (mm) = Depth Con. DN2 (mm) = Depth Con. DN3 (mm) = Depth Con. DN4 (mm) | Height (mm) | Volume (m3) | Connection DN3 | Connection DN4
394206 | 90 | 6.74497 | 2800 | 3000 | 0.348607 | yes | yes
394207 | 90 | 6.24232 | 2550 | 2750 | 0.327744 | yes | no
394208 | 90 | 5.73966 | 2300 | 2500 | 0.307637 | no | yes
394209 | 90 | 5.23701 | 2050 | 2250 | 0.286775 | no | no
394210 | 135 | 6.74498 | 2800 | 3000 | 0.348607 | yes | yes
394211 | 135 | 6.24233 | 2550 | 2750 | 0.327745 | yes | no
394212 | 135 | 5.73967 | 2300 | 2500 | 0.307638 | no | yes
394213 | 135 | 5.23702 | 2050 | 2250 | 0.286776 | no | no

# IfcBuildingElementProxy: AWASCHACHT:DN 1000 (8)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Generic Models; Cone height: 790 mm; DN/Di Chamber: 1000 mm; Do Chamber: 1096 mm; Family Name: AWASCHACHT; Z: 660 mm
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.00.00; Type Name: DN 1000
Type - Materials and Finishes - Mat. APP: AWADUKT PP SN10
Type - Visibility - AWASCHACHT Cone Type: AWASCHACHT Cone : DN 1000; DN 1000: yes
Pset_BuildingElementProxyCommon - Reference: AWASCHACHT:DN 1000; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: AWASCHACHT:DN 1000
Other - Di2: 295 mm; Di3: 295 mm; Di4: 295 mm; Family: AWASCHACHT; Family and Type: AWASCHACHT: DN 1000; Type: DN 1000; Type Id: 376655; Z 1: 390 mm; Z 2: 347.5 mm; Z 3: 347.5 mm; Z 4: 347.5 mm
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Offset from Host: 0 mm; Work Plane: Level : Ground floor
Dimensions - Cone Rotation: 90 deg; Di1: 380 mm; DN1: 400 mm; DN2: 315 mm; DN3: 315 mm; DN4: 315 mm
Phasing - Phase Created: New Construction
Visibility - Connection DN2: yes
Name (AWASCHACHT:DN 1000:...) | Angle DN2 (deg) = Angle DN4 (deg) | Area (m2) | Depth Con. DN1 (mm) = Depth Con. DN2 (mm) = Depth Con. DN3 (mm) = Depth Con. DN4 (mm) | Height (mm) | Volume (m3) | Connection DN3 | Connection DN4
376685 | 90 | 9.44073 | 2800 | 3000 | 0.688202 | yes | yes
376869 | 90 | 8.61765 | 2550 | 2750 | 0.647513 | yes | no
376878 | 90 | 7.79455 | 2300 | 2500 | 0.607999 | no | yes
376889 | 90 | 6.97145 | 2050 | 2250 | 0.56731 | no | no
377185 | 135 | 9.44072 | 2800 | 3000 | 0.688203 | yes | yes
377188 | 135 | 8.6176 | 2550 | 2750 | 0.647514 | yes | no
377191 | 135 | 7.7945 | 2300 | 2500 | 0.608 | no | yes
377194 | 135 | 6.97143 | 2050 | 2250 | 0.567311 | no | no | Group: Sanitary 85

# IfcBuildingElementProxy: AWASCHACHT:DN 800 (8)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Generic Models; Cone height: 705 mm; DN/Di Chamber: 806 mm; Do Chamber: 888 mm; Family Name: AWASCHACHT; Z: 563 mm
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.00.00; Type Name: DN 800
Type - Materials and Finishes - Mat. APP: AWADUKT PP SN10
Type - Visibility - DN 1000: yes; AWASCHACHT Cone Type: AWASCHACHT Cone : DN 800
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: AWASCHACHT:DN 800
Pset_EnvironmentalImpactIndicators - Reference: AWASCHACHT:DN 800
Other - Family: AWASCHACHT; Di2: 295 mm; Di3: 295 mm; Di4: 295 mm; Family and Type: AWASCHACHT: DN 800; Type: DN 800; Type Id: 376657; Z 1: 390 mm; Z 2: 347.5 mm; Z 3: 347.5 mm; Z 4: 347.5 mm
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Schedule Level: Ground floor; Offset from Host: 0 mm; Work Plane: Level : Ground floor
Dimensions - Cone Rotation: 90 deg; Di1: 380 mm; DN1: 400 mm; DN2: 315 mm; DN3: 315 mm; DN4: 315 mm
Phasing - Phase Created: New Construction
Visibility - Connection DN2: yes
Name (AWASCHACHT:DN 800:...) | Angle DN2 (deg) = Angle DN4 (deg) | Area (m2) | Depth Con. DN1 (mm) = Depth Con. DN2 (mm) = Depth Con. DN3 (mm) = Depth Con. DN4 (mm) | Height (mm) | Volume (m3) | Connection DN3 | Connection DN4
376823 | 90 | 7.85983 | 2800 | 3000 | 0.472766 | yes | yes
376871 | 90 | 7.1946 | 2550 | 2750 | 0.444222 | yes | no
376880 | 90 | 6.52937 | 2300 | 2500 | 0.416944 | no | yes
376891 | 90 | 5.86414 | 2050 | 2250 | 0.3884 | no | no
377187 | 135 | 7.85981 | 2800 | 3000 | 0.472768 | yes | yes
377190 | 135 | 7.19457 | 2550 | 2750 | 0.444224 | yes | no
377193 | 135 | 6.52934 | 2300 | 2500 | 0.416946 | no | yes
377196 | 135 | 5.86411 | 2050 | 2250 | 0.388402 | no | no

# IfcBuildingElementProxy: AWS Hybrid Bearing:AWS Hybrid Bearing Orange (8)
In: Ground floor
Type - Material: AWADUKT PP SN10, Concrete, Precast
Type - Other - Category: Generic Models; Family Name: AWS Hybrid Bearing; T1: AWS Hybrid Bearing
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Description long: AWASCHACHT PP hybrid bearing ring DN 625, for AWAS 600, orange f. WW; Description short: AWASCHACHT PP Orange; ETIM Class: -; ETIM Group: -; ETIM Name: -; GTIN: 4064299230049; Manufacturer: REHAU; Model: AWASCHACHT; PID: 11914671001; Product Group: 27864; Product URL: https://oxomi.com/p/3000126/datasheet/-/11914671001; REHAU Info: 17.12.2024-420668-420668; Sorting: 28060; Tender text: -; Type Name: AWS Hybrid Bearing Orange; Weight: 195
Type - Materials and Finishes - Mat. Inner surface: AWADUKT PP SN10; Mat. Structure: Concrete, Precast
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: AWS Hybrid Bearing:AWS Hybrid Bearing Orange
Pset_EnvironmentalImpactIndicators - Reference: AWS Hybrid Bearing:AWS Hybrid Bearing Orange
Other - Family: AWS Hybrid Bearing; Family and Type: AWS Hybrid Bearing: AWS Hybrid Bearing Orange; Type: AWS Hybrid Bearing Orange; Type Id: 394403
Constraints - Moves With Nearby Elements: no; Elevation from Level: -20 mm; Offset from Host: -20 mm
Dimensions - Area: 1.42917 m2; Volume: 0.0751414 m3
Phasing - Phase Created: New Construction
Name (AWS Hybrid Bearing:AWS Hybrid Bearing Orange:...)
403073
403076
403079
403082
403085
403088
403091
403094

# IfcBuildingElementProxy: AWS PP Chamber Cover:AWS PP Chamber Cover (8)
In: Ground floor
Type - Material: PP RAL 7043
Type - Other - Category: Generic Models; Family Name: AWS PP Chamber Cover; T1: AWS PP Chamber Cover
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; PID Check: 1 mm; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Description long: AWASCHACHT PP plastic cover resilient to 200 kg incl. catch; Description short: AWS PP Chamber Cover; ETIM Class: -; ETIM Group: -; ETIM Name: -; GTIN: 4007360390150; Manufacturer: REHAU; Model: AWASCHACHT; PID: 11904761001; Product Group: 27822; Product URL: https://oxomi.com/p/3000126/datasheet/-/11904761001; REHAU Info: 17.12.2024-420668-420668; Sorting: 28018; Tender text: -; Type Name: AWS PP Chamber Cover; Weight: 10
Type - Materials and Finishes - Mat. Structure: PP RAL 7043
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: AWS PP Chamber Cover:AWS PP Chamber Cover
Pset_EnvironmentalImpactIndicators - Reference: AWS PP Chamber Cover:AWS PP Chamber Cover
Other - Family: AWS PP Chamber Cover; Family and Type: AWS PP Chamber Cover: AWS PP Chamber Cover; Type: AWS PP Chamber Cover; Type Id: 394379
Constraints - Moves With Nearby Elements: no; Elevation from Level: 0.000831223 mm; Offset from Host: 0.000831223 mm
Dimensions - Area: 1.02364 m2; Volume: 0.0159747 m3
Phasing - Phase Created: New Construction
Name (AWS PP Chamber Cover:AWS PP Chamber Cover:...)
403074
403077
403080
403083
403086
403089
403092
403095

# IfcBuildingElementProxy: Model Text:Model Text 1 (21)
In: Ground floor
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: Model Text 1
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 250 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:Model Text 1
Pset_EnvironmentalImpactIndicators - Reference: Model Text:Model Text 1
Other - Family: Model Text; Family and Type: Model Text: Model Text 1; Type: Model Text 1; Type Id: 1972
Constraints - Work Plane: Level : Ground floor
Dimensions - Depth: 100 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Model Text:Model Text 1:...) | Text
377578 | DN 110
377635 | DN 160
377643 | DN 200
377651 | DN 250
377659 | DN 315
377669 | DN 400
377677 | DN 500
377687 | DN 630
377763 | DN 110
377764 | DN 160
377765 | DN 200
377766 | DN 250
377767 | DN 315
377768 | DN 400
377769 | DN 500
377770 | DN 630
385304 | AWADUKT PP SN 10 Blue
385716 | AWADUKT Nevo PP SN 10 Blue
385744 | AWADUKT PP SN 10 Blue
385746 | AWADUKT Nevo PP SN 10 Blue
385774 | AWASCHACHT

# IfcDistributionPort (1558)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name | SystemType
Port_228974_0 | SEWAGE | Group: Sanitary 1
Port_228974_1 | SEWAGE | Group: Sanitary 1
Port_229055_0 | SEWAGE | Group: Sanitary 2
Port_229055_1 | SEWAGE | Group: Sanitary 2
Port_229115_0 | SEWAGE | Group: Sanitary 3
Port_229115_1 | SEWAGE | Group: Sanitary 3
Port_229158_0 | SEWAGE | Group: Sanitary 4
Port_229158_1 | SEWAGE | Group: Sanitary 4
Port_229160_0 | SEWAGE | Group: Sanitary 5
Port_229160_1 | SEWAGE | Group: Sanitary 5
Port_229162_0 | SEWAGE | Group: Sanitary 6
Port_229162_1 | SEWAGE | Group: Sanitary 6
Port_229196_0 | SEWAGE | Group: Sanitary 7
Port_229196_1 | SEWAGE | Group: Sanitary 7
Port_229198_0 | SEWAGE | Group: Sanitary 8
Port_229198_1 | SEWAGE | Group: Sanitary 8
Port_229200_0 | SEWAGE | Group: Sanitary 9
Port_229200_1 | SEWAGE | Group: Sanitary 9
Port_229207_0 | SEWAGE | Group: Sanitary 10
Port_229207_1 | SEWAGE | Group: Sanitary 10
Port_229209_0 | SEWAGE | Group: Sanitary 11
Port_229209_1 | SEWAGE | Group: Sanitary 11
Port_229211_0 | SEWAGE | Group: Sanitary 12
Port_229211_1 | SEWAGE | Group: Sanitary 12
Port_229218_0 | SEWAGE | Group: Sanitary 13
Port_229218_1 | SEWAGE | Group: Sanitary 13
Port_229220_0 | SEWAGE | Group: Sanitary 14
Port_229220_1 | SEWAGE | Group: Sanitary 14
Port_229222_0 | SEWAGE | Group: Sanitary 15
Port_229222_1 | SEWAGE | Group: Sanitary 15
Port_229229_0 | SEWAGE | Group: Sanitary 16
Port_229229_1 | SEWAGE | Group: Sanitary 16
Port_229231_0 | SEWAGE | Group: Sanitary 17
Port_229231_1 | SEWAGE | Group: Sanitary 17
Port_229233_0 | SEWAGE | Group: Sanitary 18
Port_229233_1 | SEWAGE | Group: Sanitary 18
Port_229261_0 | SEWAGE | Group: Sanitary 19
Port_229261_1 | SEWAGE | Group: Sanitary 19
Port_229263_0 | SEWAGE | Group: Sanitary 20
Port_229263_1 | SEWAGE | Group: Sanitary 20
Port_229265_0 | SEWAGE | Group: Sanitary 21
Port_229265_1 | SEWAGE | Group: Sanitary 21
Port_229272_0 | SEWAGE | Group: Sanitary 22
Port_229272_1 | SEWAGE | Group: Sanitary 22
Port_229274_0 | SEWAGE | Group: Sanitary 23
Port_229274_1 | SEWAGE | Group: Sanitary 23
Port_229276_0 | SEWAGE | Group: Sanitary 24
Port_229276_1 | SEWAGE | Group: Sanitary 24
Port_229367_3
Port_229367_4
Port_229368_1 | SEWAGE
Port_229368_2 | SEWAGE
Port_229721_3
Port_229721_4
Port_229722_1 | SEWAGE
Port_229722_2 | SEWAGE
Port_229778_3
Port_229778_4
Port_229779_1 | SEWAGE
Port_229779_2 | SEWAGE
Port_229842_3
Port_229842_4
Port_229843_1 | SEWAGE
Port_229843_2 | SEWAGE
Port_229890_3
Port_229890_4
Port_229891_1 | SEWAGE
Port_229891_2 | SEWAGE
Port_229934_3
Port_229934_4
Port_229935_1 | SEWAGE
Port_229935_2 | SEWAGE
Port_229973_3
Port_229973_4
Port_230003_1 | SEWAGE
Port_230003_2 | SEWAGE
Port_230005_1 | SEWAGE
Port_230005_2 | SEWAGE
Port_230142_3
Port_230142_4
Port_230144_1 | SEWAGE
Port_230144_2 | SEWAGE
Port_230146_1 | SEWAGE
Port_230146_2 | SEWAGE
Port_230252_3
Port_230252_4
Port_230253_1 | SEWAGE
Port_230253_2 | SEWAGE
Port_230256_3
Port_230256_4
Port_230257_1 | SEWAGE
Port_230257_2 | SEWAGE
Port_230260_3
Port_230260_4
Port_230261_1 | SEWAGE
Port_230261_2 | SEWAGE
Port_230264_3
Port_230264_4
Port_230265_1 | SEWAGE
Port_230265_2 | SEWAGE
Port_230268_3
Port_230268_4
Port_230269_1 | SEWAGE
Port_230269_2 | SEWAGE
Port_230272_3
Port_230272_4
Port_230273_1 | SEWAGE
Port_230273_2 | SEWAGE
Port_230276_3
Port_230276_4
Port_230278_1 | SEWAGE
Port_230278_2 | SEWAGE
Port_230280_1 | SEWAGE
Port_230280_2 | SEWAGE
Port_230282_3
Port_230282_4
Port_230284_1 | SEWAGE
Port_230284_2 | SEWAGE
Port_230286_1 | SEWAGE
Port_230286_2 | SEWAGE
Port_230359_3
Port_230359_4
Port_230360_1 | SEWAGE
Port_230360_2 | SEWAGE
Port_230363_3
Port_230363_4
Port_230364_1 | SEWAGE
Port_230364_2 | SEWAGE
Port_230367_3
Port_230367_4
Port_230368_1 | SEWAGE
Port_230368_2 | SEWAGE
Port_230371_3
Port_230371_4
Port_230372_1 | SEWAGE
Port_230372_2 | SEWAGE
Port_230375_3
Port_230375_4
Port_230376_1 | SEWAGE
Port_230376_2 | SEWAGE
Port_230379_3
Port_230379_4
Port_230380_1 | SEWAGE
Port_230380_2 | SEWAGE
Port_230383_3
Port_230383_4
Port_230385_1 | SEWAGE
Port_230385_2 | SEWAGE
Port_230387_1 | SEWAGE
Port_230387_2 | SEWAGE
Port_230389_3
Port_230389_4
Port_230391_1 | SEWAGE
Port_230391_2 | SEWAGE
Port_230393_1 | SEWAGE
Port_230393_2 | SEWAGE
Port_230455_3
Port_230455_4
Port_230456_1 | SEWAGE
Port_230456_2 | SEWAGE
Port_230459_3
Port_230459_4
Port_230460_1 | SEWAGE
Port_230460_2 | SEWAGE
Port_230463_3
Port_230463_4
Port_230464_1 | SEWAGE
Port_230464_2 | SEWAGE
Port_230467_3
Port_230467_4
Port_230468_1 | SEWAGE
Port_230468_2 | SEWAGE
Port_230471_3
Port_230471_4
Port_230472_1 | SEWAGE
Port_230472_2 | SEWAGE
Port_230475_3
Port_230475_4
Port_230476_1 | SEWAGE
Port_230476_2 | SEWAGE
Port_230479_3
Port_230479_4
Port_230481_1 | SEWAGE
Port_230481_2 | SEWAGE
Port_230483_1 | SEWAGE
Port_230483_2 | SEWAGE
Port_230485_3
Port_230485_4
Port_230487_1 | SEWAGE
Port_230487_2 | SEWAGE
Port_230489_1 | SEWAGE
Port_230489_2 | SEWAGE
Port_230667_1
Port_230667_2
Port_230667_3
Port_230668_1 | SEWAGE
Port_230668_2 | SEWAGE
Port_230900_1
Port_230900_2
Port_230900_3
Port_230901_1 | SEWAGE
Port_230901_2 | SEWAGE
Port_230911_1
Port_230911_2
Port_230911_3
Port_230912_1 | SEWAGE
Port_230912_2 | SEWAGE
Port_230922_1
Port_230922_2
Port_230922_3
Port_230923_1 | SEWAGE
Port_230923_2 | SEWAGE
Port_230935_1
Port_230935_2
Port_230935_3
Port_230936_1 | SEWAGE
Port_230936_2 | SEWAGE
Port_230946_1
Port_230946_2
Port_230946_3
Port_230947_1 | SEWAGE
Port_230947_2 | SEWAGE
Port_230957_1
Port_230957_2
Port_230957_3
Port_230958_1 | SEWAGE
Port_230958_2 | SEWAGE
Port_230968_1
Port_230968_2
Port_230968_3
Port_230969_1 | SEWAGE
Port_230969_2 | SEWAGE
Port_231257_1 | SEWAGE
Port_231257_2 | SEWAGE
Port_231259_1 | SEWAGE
Port_231259_2 | SEWAGE
Port_231281_1 | SEWAGE
Port_231281_2 | SEWAGE
Port_231283_1 | SEWAGE
Port_231283_2 | SEWAGE
Port_231304_1 | SEWAGE
Port_231304_2 | SEWAGE
Port_231306_1 | SEWAGE
Port_231306_2 | SEWAGE
Port_231323_1 | SEWAGE
Port_231323_2 | SEWAGE
Port_231325_1 | SEWAGE
Port_231325_2 | SEWAGE
Port_231399_1
Port_231399_2
Port_231399_3
Port_231400_1 | SEWAGE
Port_231400_2 | SEWAGE
Port_231403_1
Port_231403_2
Port_231403_3
Port_231404_1 | SEWAGE
Port_231404_2 | SEWAGE
Port_231407_1
Port_231407_2
Port_231407_3
Port_231408_1 | SEWAGE
Port_231408_2 | SEWAGE
Port_231411_1
Port_231411_2
Port_231411_3
Port_231412_1 | SEWAGE
Port_231412_2 | SEWAGE
Port_231415_1
Port_231415_2
Port_231415_3
Port_231416_1 | SEWAGE
Port_231416_2 | SEWAGE
Port_231419_1
Port_231419_2
Port_231419_3
Port_231420_1 | SEWAGE
Port_231420_2 | SEWAGE
Port_231423_1
Port_231423_2
Port_231423_3
Port_231424_1 | SEWAGE
Port_231424_2 | SEWAGE
Port_231787_1
Port_231787_2
Port_231787_3
Port_231788_1 | SEWAGE
Port_231788_2 | SEWAGE
Port_231791_1
Port_231791_2
Port_231791_3
Port_231792_1 | SEWAGE
Port_231792_2 | SEWAGE
Port_231795_1
Port_231795_2
Port_231795_3
Port_231796_1 | SEWAGE
Port_231796_2 | SEWAGE
Port_231799_1
Port_231799_2
Port_231799_3
Port_231800_1 | SEWAGE
Port_231800_2 | SEWAGE
Port_231803_1
Port_231803_2
Port_231803_3
Port_231804_1 | SEWAGE
Port_231804_2 | SEWAGE
Port_231865_1
Port_231865_2
Port_231865_3
Port_231866_1 | SEWAGE
Port_231866_2 | SEWAGE
Port_231869_1
Port_231869_2
Port_231869_3
Port_231870_1 | SEWAGE
Port_231870_2 | SEWAGE
Port_231873_1
Port_231873_2
Port_231873_3
Port_231874_1 | SEWAGE
Port_231874_2 | SEWAGE
Port_231877_1
Port_231877_2
Port_231877_3
Port_231878_1 | SEWAGE
Port_231878_2 | SEWAGE
Port_231989_1 | SEWAGE
Port_231989_2 | SEWAGE
Port_231991_1 | SEWAGE
Port_231991_2 | SEWAGE
Port_231996_1 | SEWAGE
Port_231996_2 | SEWAGE
Port_231998_1 | SEWAGE
Port_231998_2 | SEWAGE
Port_232002_1 | SEWAGE
Port_232002_2 | SEWAGE
Port_232004_1 | SEWAGE
Port_232004_2 | SEWAGE
Port_232008_1 | SEWAGE
Port_232008_2 | SEWAGE
Port_232010_1 | SEWAGE
Port_232010_2 | SEWAGE
Port_232119_1
Port_232119_2
Port_232119_3
Port_232120_1 | SEWAGE
Port_232120_2 | SEWAGE
Port_232123_1
Port_232123_2
Port_232123_3
Port_232124_1 | SEWAGE
Port_232124_2 | SEWAGE
Port_232127_1
Port_232127_2
Port_232127_3
Port_232128_1 | SEWAGE
Port_232128_2 | SEWAGE
Port_232136_1 | SEWAGE
Port_232136_2 | SEWAGE
Port_232138_1 | SEWAGE
Port_232138_2 | SEWAGE
Port_232140_1 | SEWAGE
Port_232140_2 | SEWAGE
Port_232142_1 | SEWAGE
Port_232142_2 | SEWAGE
Port_232144_1 | SEWAGE
Port_232144_2 | SEWAGE
Port_232146_1 | SEWAGE
Port_232146_2 | SEWAGE
Port_232205_1
Port_232205_2
Port_232205_3
Port_232206_1 | SEWAGE
Port_232206_2 | SEWAGE
Port_232209_1
Port_232209_2
Port_232209_3
Port_232210_1 | SEWAGE
Port_232210_2 | SEWAGE
Port_232218_1 | SEWAGE
Port_232218_2 | SEWAGE
Port_232220_1 | SEWAGE
Port_232220_2 | SEWAGE
Port_232222_1 | SEWAGE
Port_232222_2 | SEWAGE
Port_232224_1 | SEWAGE
Port_232224_2 | SEWAGE
Port_232263_1
Port_232263_2
Port_232263_3
Port_232264_1 | SEWAGE
Port_232264_2 | SEWAGE
Port_232272_1 | SEWAGE
Port_232272_2 | SEWAGE
Port_232274_1 | SEWAGE
Port_232274_2 | SEWAGE
Port_232446_1
Port_232446_2
Port_232446_3
Port_232447_1 | SEWAGE
Port_232447_2 | SEWAGE
Port_232450_1
Port_232450_2
Port_232450_3
Port_232451_1 | SEWAGE
Port_232451_2 | SEWAGE
Port_232454_1
Port_232454_2
Port_232454_3
Port_232455_1 | SEWAGE
Port_232455_2 | SEWAGE
Port_232458_1
Port_232458_2
Port_232458_3
Port_232459_1 | SEWAGE
Port_232459_2 | SEWAGE
Port_232462_1
Port_232462_2
Port_232462_3
Port_232463_1 | SEWAGE
Port_232463_2 | SEWAGE
Port_232466_1
Port_232466_2
Port_232466_3
Port_232467_1 | SEWAGE
Port_232467_2 | SEWAGE
Port_232470_1
Port_232470_2
Port_232470_3
Port_232471_1 | SEWAGE
Port_232471_2 | SEWAGE
Port_232495_1
Port_232495_2
Port_232495_3
Port_232496_1 | SEWAGE
Port_232496_2 | SEWAGE
Port_232499_1
Port_232499_2
Port_232499_3
Port_232500_1 | SEWAGE
Port_232500_2 | SEWAGE
Port_232503_1
Port_232503_2
Port_232503_3
Port_232504_1 | SEWAGE
Port_232504_2 | SEWAGE
Port_232507_1
Port_232507_2
Port_232507_3
Port_232508_1 | SEWAGE
Port_232508_2 | SEWAGE
Port_232511_1
Port_232511_2
Port_232511_3
Port_232512_1 | SEWAGE
Port_232512_2 | SEWAGE
Port_232515_1
Port_232515_2
Port_232515_3
Port_232516_1 | SEWAGE
Port_232516_2 | SEWAGE
Port_232520_1
Port_232520_2
Port_232520_3
Port_232521_1 | SEWAGE
Port_232521_2 | SEWAGE
Port_232524_1
Port_232524_2
Port_232524_3
Port_232525_1 | SEWAGE
Port_232525_2 | SEWAGE
Port_232528_1
Port_232528_2
Port_232528_3
Port_232529_1 | SEWAGE
Port_232529_2 | SEWAGE
Port_232532_1
Port_232532_2
Port_232532_3
Port_232533_1 | SEWAGE
Port_232533_2 | SEWAGE
Port_232536_1
Port_232536_2
Port_232536_3
Port_232537_1 | SEWAGE
Port_232537_2 | SEWAGE
Port_232541_1
Port_232541_2
Port_232541_3
Port_232542_1 | SEWAGE
Port_232542_2 | SEWAGE
Port_232545_1
Port_232545_2
Port_232545_3
Port_232546_1 | SEWAGE
Port_232546_2 | SEWAGE
Port_232549_1
Port_232549_2
Port_232549_3
Port_232550_1 | SEWAGE
Port_232550_2 | SEWAGE
Port_232553_1
Port_232553_2
Port_232553_3
Port_232554_1 | SEWAGE
Port_232554_2 | SEWAGE
Port_232574_1
Port_232574_2
Port_232574_3
Port_232575_1 | SEWAGE
Port_232575_2 | SEWAGE
Port_232578_1
Port_232578_2
Port_232578_3
Port_232579_1 | SEWAGE
Port_232579_2 | SEWAGE
Port_232582_1
Port_232582_2
Port_232582_3
Port_232583_1 | SEWAGE
Port_232583_2 | SEWAGE
Port_232599_1
Port_232599_2
Port_232599_3
Port_232600_1 | SEWAGE
Port_232600_2 | SEWAGE
Port_232603_1
Port_232603_2
Port_232603_3
Port_232604_1 | SEWAGE
Port_232604_2 | SEWAGE
Port_232616_1
Port_232616_2
Port_232616_3
Port_232617_1 | SEWAGE
Port_232617_2 | SEWAGE
Port_242064_1
Port_242064_2
Port_242064_3
Port_242065_1 | SEWAGE
Port_242065_2 | SEWAGE
Port_250900_1 | SEWAGE
Port_250900_2 | SEWAGE
Port_250902_1 | SEWAGE
Port_250902_2 | SEWAGE
Port_250907_1 | SEWAGE
Port_250907_2 | SEWAGE
Port_250909_1 | SEWAGE
Port_250909_2 | SEWAGE
Port_250914_1 | SEWAGE
Port_250914_2 | SEWAGE
Port_250916_1 | SEWAGE
Port_250916_2 | SEWAGE
Port_250919_1 | SEWAGE
Port_250919_2 | SEWAGE
Port_250921_1 | SEWAGE
Port_250921_2 | SEWAGE
Port_250932_1 | SEWAGE
Port_250932_2 | SEWAGE
Port_250934_1 | SEWAGE
Port_250934_2 | SEWAGE
Port_250939_1 | SEWAGE
Port_250939_2 | SEWAGE
Port_250941_1 | SEWAGE
Port_250941_2 | SEWAGE
Port_250946_1 | SEWAGE
Port_250946_2 | SEWAGE
Port_250948_1 | SEWAGE
Port_250948_2 | SEWAGE
Port_250951_1 | SEWAGE
Port_250951_2 | SEWAGE
Port_250953_1 | SEWAGE
Port_250953_2 | SEWAGE
Port_250963_1 | SEWAGE
Port_250963_2 | SEWAGE
Port_250965_1 | SEWAGE
Port_250965_2 | SEWAGE
Port_250971_1 | SEWAGE
Port_250971_2 | SEWAGE
Port_250973_1 | SEWAGE
Port_250973_2 | SEWAGE
Port_250979_1 | SEWAGE
Port_250979_2 | SEWAGE
Port_250981_1 | SEWAGE
Port_250981_2 | SEWAGE
Port_250985_1 | SEWAGE
Port_250985_2 | SEWAGE
Port_250987_1 | SEWAGE
Port_250987_2 | SEWAGE
Port_250993_1 | SEWAGE
Port_250993_2 | SEWAGE
Port_250995_1 | SEWAGE
Port_250995_2 | SEWAGE
Port_251001_1 | SEWAGE
Port_251001_2 | SEWAGE
Port_251003_1 | SEWAGE
Port_251003_2 | SEWAGE
Port_251009_1 | SEWAGE
Port_251009_2 | SEWAGE
Port_251011_1 | SEWAGE
Port_251011_2 | SEWAGE
Port_251015_1 | SEWAGE
Port_251015_2 | SEWAGE
Port_251017_1 | SEWAGE
Port_251017_2 | SEWAGE
Port_251023_1 | SEWAGE
Port_251023_2 | SEWAGE
Port_251025_1 | SEWAGE
Port_251025_2 | SEWAGE
Port_251031_1 | SEWAGE
Port_251031_2 | SEWAGE
Port_251033_1 | SEWAGE
Port_251033_2 | SEWAGE
Port_251037_1 | SEWAGE
Port_251037_2 | SEWAGE
Port_251039_1 | SEWAGE
Port_251039_2 | SEWAGE
Port_251045_1 | SEWAGE
Port_251045_2 | SEWAGE
Port_251047_1 | SEWAGE
Port_251047_2 | SEWAGE
Port_251051_1 | SEWAGE
Port_251051_2 | SEWAGE
Port_251053_1 | SEWAGE
Port_251053_2 | SEWAGE
Port_251057_1 | SEWAGE
Port_251057_2 | SEWAGE
Port_251059_1 | SEWAGE
Port_251059_2 | SEWAGE
Port_251061_1 | SEWAGE
Port_251061_2 | SEWAGE
Port_251063_1 | SEWAGE
Port_251063_2 | SEWAGE
Port_251344_1
Port_251344_2
Port_251741_1
Port_251741_2
Port_251750_1
Port_251750_2
Port_251759_1
Port_251759_2
Port_251768_1
Port_251768_2
Port_251777_1
Port_251777_2
Port_251786_1
Port_251786_2
Port_251855_1
Port_251855_2
Port_256939_1 | SEWAGE
Port_256939_2 | SEWAGE
Port_256941_1 | SEWAGE
Port_256941_2 | SEWAGE
Port_256943_1 | SEWAGE
Port_256943_2 | SEWAGE
Port_256945_1 | SEWAGE
Port_256945_2 | SEWAGE
Port_256947_1 | SEWAGE
Port_256947_2 | SEWAGE
Port_256949_1 | SEWAGE
Port_256949_2 | SEWAGE
Port_256951_1 | SEWAGE
Port_256951_2 | SEWAGE
Port_256953_1 | SEWAGE
Port_256953_2 | SEWAGE
Port_257141_2
Port_257141_3
Port_257142_1 | SEWAGE
Port_257142_2 | SEWAGE
Port_281361_2
Port_281361_3
Port_281362_1 | SEWAGE
Port_281362_2 | SEWAGE
Port_281374_2
Port_281374_3
Port_281375_1 | SEWAGE
Port_281375_2 | SEWAGE
Port_281385_2
Port_281385_3
Port_281386_1 | SEWAGE
Port_281386_2 | SEWAGE
Port_281398_2
Port_281398_3
Port_281399_1 | SEWAGE
Port_281399_2 | SEWAGE
Port_281409_2
Port_281409_3
Port_281410_1 | SEWAGE
Port_281410_2 | SEWAGE
Port_281705_0 | SEWAGE | Group: Sanitary 25
Port_281705_1 | SEWAGE | Group: Sanitary 25
Port_281707_0 | SEWAGE | Group: Sanitary 26
Port_281707_1 | SEWAGE | Group: Sanitary 26
Port_281709_0 | SEWAGE | Group: Sanitary 27
Port_281709_1 | SEWAGE | Group: Sanitary 27
Port_281711_0 | SEWAGE | Group: Sanitary 28
Port_281711_1 | SEWAGE | Group: Sanitary 28
Port_281713_0 | SEWAGE | Group: Sanitary 29
Port_281713_1 | SEWAGE | Group: Sanitary 29
Port_281715_0 | SEWAGE | Group: Sanitary 30
Port_281715_1 | SEWAGE | Group: Sanitary 30
Port_281808_0 | SEWAGE | Group: Sanitary 33
Port_281808_1 | SEWAGE | Group: Sanitary 33
Port_281810_0 | SEWAGE | Group: Sanitary 34
Port_281810_1 | SEWAGE | Group: Sanitary 34
Port_281812_0 | SEWAGE | Group: Sanitary 35
Port_281812_1 | SEWAGE | Group: Sanitary 35
Port_281814_0 | SEWAGE | Group: Sanitary 36
Port_281814_1 | SEWAGE | Group: Sanitary 36
Port_281816_0 | SEWAGE | Group: Sanitary 37
Port_281816_1 | SEWAGE | Group: Sanitary 37
Port_281818_0 | SEWAGE | Group: Sanitary 38
Port_281818_1 | SEWAGE | Group: Sanitary 38
Port_281861_0 | SEWAGE | Group: Sanitary 41
Port_281861_1 | SEWAGE | Group: Sanitary 41
Port_281863_0 | SEWAGE | Group: Sanitary 42
Port_281863_1 | SEWAGE | Group: Sanitary 42
Port_281865_0 | SEWAGE | Group: Sanitary 43
Port_281865_1 | SEWAGE | Group: Sanitary 43
Port_281867_0 | SEWAGE | Group: Sanitary 44
Port_281867_1 | SEWAGE | Group: Sanitary 44
Port_281869_0 | SEWAGE | Group: Sanitary 45
Port_281869_1 | SEWAGE | Group: Sanitary 45
Port_281871_0 | SEWAGE | Group: Sanitary 46
Port_281871_1 | SEWAGE | Group: Sanitary 46
Port_282252_0 | SEWAGE | Group: Sanitary 31
Port_282252_1 | SEWAGE | Group: Sanitary 31
Port_282254_0 | SEWAGE | Group: Sanitary 32
Port_282254_1 | SEWAGE | Group: Sanitary 32
Port_282256_0 | SEWAGE | Group: Sanitary 39
Port_282256_1 | SEWAGE | Group: Sanitary 39
Port_282258_0 | SEWAGE | Group: Sanitary 40
Port_282258_1 | SEWAGE | Group: Sanitary 40
Port_282260_0 | SEWAGE | Group: Sanitary 47
Port_282260_1 | SEWAGE | Group: Sanitary 47
Port_282262_0 | SEWAGE | Group: Sanitary 48
Port_282262_1 | SEWAGE | Group: Sanitary 48
Port_282264_0 | SEWAGE | Group: Sanitary 49
Port_282264_1 | SEWAGE | Group: Sanitary 49
Port_282266_0 | SEWAGE | Group: Sanitary 50
Port_282266_1 | SEWAGE | Group: Sanitary 50
Port_282268_0 | SEWAGE | Group: Sanitary 51
Port_282268_1 | SEWAGE | Group: Sanitary 51
Port_282270_0 | SEWAGE | Group: Sanitary 52
Port_282270_1 | SEWAGE | Group: Sanitary 52
Port_282272_0 | SEWAGE | Group: Sanitary 53
Port_282272_1 | SEWAGE | Group: Sanitary 53
Port_282274_0 | SEWAGE | Group: Sanitary 54
Port_282274_1 | SEWAGE | Group: Sanitary 54
Port_282276_0 | SEWAGE | Group: Sanitary 55
Port_282276_1 | SEWAGE | Group: Sanitary 55
Port_282278_0 | SEWAGE | Group: Sanitary 56
Port_282278_1 | SEWAGE | Group: Sanitary 56
Port_282280_0 | SEWAGE | Group: Sanitary 57
Port_282280_1 | SEWAGE | Group: Sanitary 57
Port_282282_0 | SEWAGE | Group: Sanitary 58
Port_282282_1 | SEWAGE | Group: Sanitary 58
Port_282284_0 | SEWAGE | Group: Sanitary 59
Port_282284_1 | SEWAGE | Group: Sanitary 59
Port_282286_0 | SEWAGE | Group: Sanitary 60
Port_282286_1 | SEWAGE | Group: Sanitary 60
Port_282288_0 | SEWAGE | Group: Sanitary 61
Port_282288_1 | SEWAGE | Group: Sanitary 61
Port_282290_0 | SEWAGE | Group: Sanitary 62
Port_282290_1 | SEWAGE | Group: Sanitary 62
Port_282292_0 | SEWAGE | Group: Sanitary 63
Port_282292_1 | SEWAGE | Group: Sanitary 63
Port_282294_0 | SEWAGE | Group: Sanitary 64
Port_282294_1 | SEWAGE | Group: Sanitary 64
Port_282296_0 | SEWAGE | Group: Sanitary 65
Port_282296_1 | SEWAGE | Group: Sanitary 65
Port_282298_0 | SEWAGE | Group: Sanitary 66
Port_282298_1 | SEWAGE | Group: Sanitary 66
Port_282300_3
Port_282300_4
Port_282301_1 | SEWAGE
Port_282301_2 | SEWAGE
Port_282304_3
Port_282304_4
Port_282305_1 | SEWAGE
Port_282305_2 | SEWAGE
Port_282308_3
Port_282308_4
Port_282309_1 | SEWAGE
Port_282309_2 | SEWAGE
Port_282312_3
Port_282312_4
Port_282313_1 | SEWAGE
Port_282313_2 | SEWAGE
Port_282316_3
Port_282316_4
Port_282317_1 | SEWAGE
Port_282317_2 | SEWAGE
Port_282320_3
Port_282320_4
Port_282321_1 | SEWAGE
Port_282321_2 | SEWAGE
Port_282324_3
Port_282324_4
Port_282326_1 | SEWAGE
Port_282326_2 | SEWAGE
Port_282328_1 | SEWAGE
Port_282328_2 | SEWAGE
Port_282330_3
Port_282330_4
Port_282332_1 | SEWAGE
Port_282332_2 | SEWAGE
Port_282334_1 | SEWAGE
Port_282334_2 | SEWAGE
Port_282336_3
Port_282336_4
Port_282337_1 | SEWAGE
Port_282337_2 | SEWAGE
Port_282340_3
Port_282340_4
Port_282341_1 | SEWAGE
Port_282341_2 | SEWAGE
Port_282344_3
Port_282344_4
Port_282345_1 | SEWAGE
Port_282345_2 | SEWAGE
Port_282348_3
Port_282348_4
Port_282349_1 | SEWAGE
Port_282349_2 | SEWAGE
Port_282352_3
Port_282352_4
Port_282353_1 | SEWAGE
Port_282353_2 | SEWAGE
Port_282356_3
Port_282356_4
Port_282357_1 | SEWAGE
Port_282357_2 | SEWAGE
Port_282360_3
Port_282360_4
Port_282362_1 | SEWAGE
Port_282362_2 | SEWAGE
Port_282364_1 | SEWAGE
Port_282364_2 | SEWAGE
Port_282366_3
Port_282366_4
Port_282368_1 | SEWAGE
Port_282368_2 | SEWAGE
Port_282370_1 | SEWAGE
Port_282370_2 | SEWAGE
Port_282372_3
Port_282372_4
Port_282373_1 | SEWAGE
Port_282373_2 | SEWAGE
Port_282376_3
Port_282376_4
Port_282377_1 | SEWAGE
Port_282377_2 | SEWAGE
Port_282380_3
Port_282380_4
Port_282381_1 | SEWAGE
Port_282381_2 | SEWAGE
Port_282384_3
Port_282384_4
Port_282385_1 | SEWAGE
Port_282385_2 | SEWAGE
Port_282388_3
Port_282388_4
Port_282389_1 | SEWAGE
Port_282389_2 | SEWAGE
Port_282392_3
Port_282392_4
Port_282393_1 | SEWAGE
Port_282393_2 | SEWAGE
Port_282396_3
Port_282396_4
Port_282398_1 | SEWAGE
Port_282398_2 | SEWAGE
Port_282400_1 | SEWAGE
Port_282400_2 | SEWAGE
Port_282402_3
Port_282402_4
Port_282404_1 | SEWAGE
Port_282404_2 | SEWAGE
Port_282406_1 | SEWAGE
Port_282406_2 | SEWAGE
Port_282408_3
Port_282408_4
Port_282409_1 | SEWAGE
Port_282409_2 | SEWAGE
Port_282412_3
Port_282412_4
Port_282413_1 | SEWAGE
Port_282413_2 | SEWAGE
Port_282416_3
Port_282416_4
Port_282417_1 | SEWAGE
Port_282417_2 | SEWAGE
Port_282420_3
Port_282420_4
Port_282421_1 | SEWAGE
Port_282421_2 | SEWAGE
Port_282424_3
Port_282424_4
Port_282425_1 | SEWAGE
Port_282425_2 | SEWAGE
Port_282428_3
Port_282428_4
Port_282429_1 | SEWAGE
Port_282429_2 | SEWAGE
Port_282432_3
Port_282432_4
Port_282434_1 | SEWAGE
Port_282434_2 | SEWAGE
Port_282436_1 | SEWAGE
Port_282436_2 | SEWAGE
Port_282438_3
Port_282438_4
Port_282440_1 | SEWAGE
Port_282440_2 | SEWAGE
Port_282442_1 | SEWAGE
Port_282442_2 | SEWAGE
Port_282444_1
Port_282444_2
Port_282444_3
Port_282445_1 | SEWAGE
Port_282445_2 | SEWAGE
Port_282448_1
Port_282448_2
Port_282448_3
Port_282449_1 | SEWAGE
Port_282449_2 | SEWAGE
Port_282452_1
Port_282452_2
Port_282452_3
Port_282453_1 | SEWAGE
Port_282453_2 | SEWAGE
Port_282456_1
Port_282456_2
Port_282456_3
Port_282457_1 | SEWAGE
Port_282457_2 | SEWAGE
Port_282460_1
Port_282460_2
Port_282460_3
Port_282461_1 | SEWAGE
Port_282461_2 | SEWAGE
Port_282464_1
Port_282464_2
Port_282464_3
Port_282465_1 | SEWAGE
Port_282465_2 | SEWAGE
Port_282468_1
Port_282468_2
Port_282468_3
Port_282469_1 | SEWAGE
Port_282469_2 | SEWAGE
Port_282472_1
Port_282472_2
Port_282472_3
Port_282473_1 | SEWAGE
Port_282473_2 | SEWAGE
Port_282476_1 | SEWAGE
Port_282476_2 | SEWAGE
Port_282478_1 | SEWAGE
Port_282478_2 | SEWAGE
Port_282480_1 | SEWAGE
Port_282480_2 | SEWAGE
Port_282482_1 | SEWAGE
Port_282482_2 | SEWAGE
Port_282484_1 | SEWAGE
Port_282484_2 | SEWAGE
Port_282486_1 | SEWAGE
Port_282486_2 | SEWAGE
Port_282488_1 | SEWAGE
Port_282488_2 | SEWAGE
Port_282490_1 | SEWAGE
Port_282490_2 | SEWAGE
Port_282492_1
Port_282492_2
Port_282492_3
Port_282493_1 | SEWAGE
Port_282493_2 | SEWAGE
Port_282496_1
Port_282496_2
Port_282496_3
Port_282497_1 | SEWAGE
Port_282497_2 | SEWAGE
Port_282500_1
Port_282500_2
Port_282500_3
Port_282501_1 | SEWAGE
Port_282501_2 | SEWAGE
Port_282504_1
Port_282504_2
Port_282504_3
Port_282505_1 | SEWAGE
Port_282505_2 | SEWAGE
Port_282508_1
Port_282508_2
Port_282508_3
Port_282509_1 | SEWAGE
Port_282509_2 | SEWAGE
Port_282512_1
Port_282512_2
Port_282512_3
Port_282513_1 | SEWAGE
Port_282513_2 | SEWAGE
Port_282516_1
Port_282516_2
Port_282516_3
Port_282517_1 | SEWAGE
Port_282517_2 | SEWAGE
Port_282520_1
Port_282520_2
Port_282520_3
Port_282521_1 | SEWAGE
Port_282521_2 | SEWAGE
Port_282524_1
Port_282524_2
Port_282524_3
Port_282525_1 | SEWAGE
Port_282525_2 | SEWAGE
Port_282528_1
Port_282528_2
Port_282528_3
Port_282529_1 | SEWAGE
Port_282529_2 | SEWAGE
Port_282532_1
Port_282532_2
Port_282532_3
Port_282533_1 | SEWAGE
Port_282533_2 | SEWAGE
Port_282536_1
Port_282536_2
Port_282536_3
Port_282537_1 | SEWAGE
Port_282537_2 | SEWAGE
Port_282540_1
Port_282540_2
Port_282540_3
Port_282541_1 | SEWAGE
Port_282541_2 | SEWAGE
Port_282544_1
Port_282544_2
Port_282544_3
Port_282545_1 | SEWAGE
Port_282545_2 | SEWAGE
Port_282548_1
Port_282548_2
Port_282548_3
Port_282549_1 | SEWAGE
Port_282549_2 | SEWAGE
Port_282552_1
Port_282552_2
Port_282552_3
Port_282553_1 | SEWAGE
Port_282553_2 | SEWAGE
Port_282556_1 | SEWAGE
Port_282556_2 | SEWAGE
Port_282558_1 | SEWAGE
Port_282558_2 | SEWAGE
Port_282560_1 | SEWAGE
Port_282560_2 | SEWAGE
Port_282562_1 | SEWAGE
Port_282562_2 | SEWAGE
Port_282564_1 | SEWAGE
Port_282564_2 | SEWAGE
Port_282566_1 | SEWAGE
Port_282566_2 | SEWAGE
Port_282568_1 | SEWAGE
Port_282568_2 | SEWAGE
Port_282570_1 | SEWAGE
Port_282570_2 | SEWAGE
Port_282572_1
Port_282572_2
Port_282572_3
Port_282573_1 | SEWAGE
Port_282573_2 | SEWAGE
Port_282576_1
Port_282576_2
Port_282576_3
Port_282577_1 | SEWAGE
Port_282577_2 | SEWAGE
Port_282580_1
Port_282580_2
Port_282580_3
Port_282581_1 | SEWAGE
Port_282581_2 | SEWAGE
Port_282584_1 | SEWAGE
Port_282584_2 | SEWAGE
Port_282586_1 | SEWAGE
Port_282586_2 | SEWAGE
Port_282588_1 | SEWAGE
Port_282588_2 | SEWAGE
Port_282590_1 | SEWAGE
Port_282590_2 | SEWAGE
Port_282592_1 | SEWAGE
Port_282592_2 | SEWAGE
Port_282594_1 | SEWAGE
Port_282594_2 | SEWAGE
Port_282596_1
Port_282596_2
Port_282596_3
Port_282597_1 | SEWAGE
Port_282597_2 | SEWAGE
Port_282600_1
Port_282600_2
Port_282600_3
Port_282601_1 | SEWAGE
Port_282601_2 | SEWAGE
Port_282604_1 | SEWAGE
Port_282604_2 | SEWAGE
Port_282606_1 | SEWAGE
Port_282606_2 | SEWAGE
Port_282608_1 | SEWAGE
Port_282608_2 | SEWAGE
Port_282610_1 | SEWAGE
Port_282610_2 | SEWAGE
Port_282612_1
Port_282612_2
Port_282612_3
Port_282613_1 | SEWAGE
Port_282613_2 | SEWAGE
Port_282616_1 | SEWAGE
Port_282616_2 | SEWAGE
Port_282618_1 | SEWAGE
Port_282618_2 | SEWAGE
Port_282620_1
Port_282620_2
Port_282620_3
Port_282621_1 | SEWAGE
Port_282621_2 | SEWAGE
Port_282624_1
Port_282624_2
Port_282624_3
Port_282625_1 | SEWAGE
Port_282625_2 | SEWAGE
Port_282628_1
Port_282628_2
Port_282628_3
Port_282629_1 | SEWAGE
Port_282629_2 | SEWAGE
Port_282632_1
Port_282632_2
Port_282632_3
Port_282633_1 | SEWAGE
Port_282633_2 | SEWAGE
Port_282636_1
Port_282636_2
Port_282636_3
Port_282637_1 | SEWAGE
Port_282637_2 | SEWAGE
Port_282640_1
Port_282640_2
Port_282640_3
Port_282641_1 | SEWAGE
Port_282641_2 | SEWAGE
Port_282644_1
Port_282644_2
Port_282644_3
Port_282645_1 | SEWAGE
Port_282645_2 | SEWAGE
Port_282648_1
Port_282648_2
Port_282648_3
Port_282649_1 | SEWAGE
Port_282649_2 | SEWAGE
Port_282652_1
Port_282652_2
Port_282652_3
Port_282653_1 | SEWAGE
Port_282653_2 | SEWAGE
Port_282656_1
Port_282656_2
Port_282656_3
Port_282657_1 | SEWAGE
Port_282657_2 | SEWAGE
Port_282660_1
Port_282660_2
Port_282660_3
Port_282661_1 | SEWAGE
Port_282661_2 | SEWAGE
Port_282664_1
Port_282664_2
Port_282664_3
Port_282665_1 | SEWAGE
Port_282665_2 | SEWAGE
Port_282668_1
Port_282668_2
Port_282668_3
Port_282669_1 | SEWAGE
Port_282669_2 | SEWAGE
Port_282672_1
Port_282672_2
Port_282672_3
Port_282673_1 | SEWAGE
Port_282673_2 | SEWAGE
Port_282676_1
Port_282676_2
Port_282676_3
Port_282677_1 | SEWAGE
Port_282677_2 | SEWAGE
Port_282680_1
Port_282680_2
Port_282680_3
Port_282681_1 | SEWAGE
Port_282681_2 | SEWAGE
Port_282684_1
Port_282684_2
Port_282684_3
Port_282685_1 | SEWAGE
Port_282685_2 | SEWAGE
Port_282688_1
Port_282688_2
Port_282688_3
Port_282689_1 | SEWAGE
Port_282689_2 | SEWAGE
Port_282692_1
Port_282692_2
Port_282692_3
Port_282693_1 | SEWAGE
Port_282693_2 | SEWAGE
Port_282696_1
Port_282696_2
Port_282696_3
Port_282697_1 | SEWAGE
Port_282697_2 | SEWAGE
Port_282700_1
Port_282700_2
Port_282700_3
Port_282701_1 | SEWAGE
Port_282701_2 | SEWAGE
Port_282704_1
Port_282704_2
Port_282704_3
Port_282705_1 | SEWAGE
Port_282705_2 | SEWAGE
Port_282708_1
Port_282708_2
Port_282708_3
Port_282709_1 | SEWAGE
Port_282709_2 | SEWAGE
Port_282712_1
Port_282712_2
Port_282712_3
Port_282713_1 | SEWAGE
Port_282713_2 | SEWAGE
Port_282716_1
Port_282716_2
Port_282716_3
Port_282717_1 | SEWAGE
Port_282717_2 | SEWAGE
Port_282720_1
Port_282720_2
Port_282720_3
Port_282721_1 | SEWAGE
Port_282721_2 | SEWAGE
Port_282724_1
Port_282724_2
Port_282724_3
Port_282725_1 | SEWAGE
Port_282725_2 | SEWAGE
Port_282728_1
Port_282728_2
Port_282728_3
Port_282729_1 | SEWAGE
Port_282729_2 | SEWAGE
Port_282732_1
Port_282732_2
Port_282732_3
Port_282733_1 | SEWAGE
Port_282733_2 | SEWAGE
Port_282736_1 | SEWAGE
Port_282736_2 | SEWAGE
Port_282738_1 | SEWAGE
Port_282738_2 | SEWAGE
Port_282740_1 | SEWAGE
Port_282740_2 | SEWAGE
Port_282742_1 | SEWAGE
Port_282742_2 | SEWAGE
Port_282744_1 | SEWAGE
Port_282744_2 | SEWAGE
Port_282746_1 | SEWAGE
Port_282746_2 | SEWAGE
Port_282748_1 | SEWAGE
Port_282748_2 | SEWAGE
Port_282750_1 | SEWAGE
Port_282750_2 | SEWAGE
Port_282752_1 | SEWAGE
Port_282752_2 | SEWAGE
Port_282754_1 | SEWAGE
Port_282754_2 | SEWAGE
Port_282756_1 | SEWAGE
Port_282756_2 | SEWAGE
Port_282758_1 | SEWAGE
Port_282758_2 | SEWAGE
Port_282760_1 | SEWAGE
Port_282760_2 | SEWAGE
Port_282762_1 | SEWAGE
Port_282762_2 | SEWAGE
Port_282764_1 | SEWAGE
Port_282764_2 | SEWAGE
Port_282766_1 | SEWAGE
Port_282766_2 | SEWAGE
Port_282768_1 | SEWAGE
Port_282768_2 | SEWAGE
Port_282770_1 | SEWAGE
Port_282770_2 | SEWAGE
Port_282772_1 | SEWAGE
Port_282772_2 | SEWAGE
Port_282774_1 | SEWAGE
Port_282774_2 | SEWAGE
Port_282776_1 | SEWAGE
Port_282776_2 | SEWAGE
Port_282778_1 | SEWAGE
Port_282778_2 | SEWAGE
Port_282780_1 | SEWAGE
Port_282780_2 | SEWAGE
Port_282782_1 | SEWAGE
Port_282782_2 | SEWAGE
Port_282784_1 | SEWAGE
Port_282784_2 | SEWAGE
Port_282786_1 | SEWAGE
Port_282786_2 | SEWAGE
Port_282788_1 | SEWAGE
Port_282788_2 | SEWAGE
Port_282790_1 | SEWAGE
Port_282790_2 | SEWAGE
Port_282792_1 | SEWAGE
Port_282792_2 | SEWAGE
Port_282794_1 | SEWAGE
Port_282794_2 | SEWAGE
Port_282796_1 | SEWAGE
Port_282796_2 | SEWAGE
Port_282798_1 | SEWAGE
Port_282798_2 | SEWAGE
Port_282800_1 | SEWAGE
Port_282800_2 | SEWAGE
Port_282802_1 | SEWAGE
Port_282802_2 | SEWAGE
Port_282804_1 | SEWAGE
Port_282804_2 | SEWAGE
Port_282806_1 | SEWAGE
Port_282806_2 | SEWAGE
Port_282808_1 | SEWAGE
Port_282808_2 | SEWAGE
Port_282810_1 | SEWAGE
Port_282810_2 | SEWAGE
Port_282812_1 | SEWAGE
Port_282812_2 | SEWAGE
Port_282814_1 | SEWAGE
Port_282814_2 | SEWAGE
Port_282816_1 | SEWAGE
Port_282816_2 | SEWAGE
Port_282818_1 | SEWAGE
Port_282818_2 | SEWAGE
Port_282820_1 | SEWAGE
Port_282820_2 | SEWAGE
Port_282822_1 | SEWAGE
Port_282822_2 | SEWAGE
Port_282824_1 | SEWAGE
Port_282824_2 | SEWAGE
Port_282826_1 | SEWAGE
Port_282826_2 | SEWAGE
Port_282828_1
Port_282828_2
Port_282830_1
Port_282830_2
Port_282832_1
Port_282832_2
Port_282834_1
Port_282834_2
Port_282836_1
Port_282836_2
Port_282838_1
Port_282838_2
Port_282840_1
Port_282840_2
Port_282842_1
Port_282842_2
Port_282844_1 | SEWAGE
Port_282844_2 | SEWAGE
Port_282846_1 | SEWAGE
Port_282846_2 | SEWAGE
Port_282848_1 | SEWAGE
Port_282848_2 | SEWAGE
Port_282850_1 | SEWAGE
Port_282850_2 | SEWAGE
Port_282852_1 | SEWAGE
Port_282852_2 | SEWAGE
Port_282854_1 | SEWAGE
Port_282854_2 | SEWAGE
Port_282856_1 | SEWAGE
Port_282856_2 | SEWAGE
Port_282858_1 | SEWAGE
Port_282858_2 | SEWAGE
Port_282860_2
Port_282860_3
Port_282861_1 | SEWAGE
Port_282861_2 | SEWAGE
Port_282864_2
Port_282864_3
Port_282865_1 | SEWAGE
Port_282865_2 | SEWAGE
Port_282868_2
Port_282868_3
Port_282869_1 | SEWAGE
Port_282869_2 | SEWAGE
Port_282872_2
Port_282872_3
Port_282873_1 | SEWAGE
Port_282873_2 | SEWAGE
Port_282876_2
Port_282876_3
Port_282877_1 | SEWAGE
Port_282877_2 | SEWAGE
Port_282880_2
Port_282880_3
Port_282881_1 | SEWAGE
Port_282881_2 | SEWAGE
Port_282884_0 | SEWAGE | Group: Sanitary 67
Port_282884_1 | SEWAGE | Group: Sanitary 67
Port_282886_0 | SEWAGE | Group: Sanitary 68
Port_282886_1 | SEWAGE | Group: Sanitary 68
Port_282888_0 | SEWAGE | Group: Sanitary 69
Port_282888_1 | SEWAGE | Group: Sanitary 69
Port_282890_0 | SEWAGE | Group: Sanitary 70
Port_282890_1 | SEWAGE | Group: Sanitary 70
Port_282892_0 | SEWAGE | Group: Sanitary 71
Port_282892_1 | SEWAGE | Group: Sanitary 71
Port_282894_0 | SEWAGE | Group: Sanitary 72
Port_282894_1 | SEWAGE | Group: Sanitary 72
Port_282896_0 | SEWAGE | Group: Sanitary 73
Port_282896_1 | SEWAGE | Group: Sanitary 73
Port_282898_0 | SEWAGE | Group: Sanitary 74
Port_282898_1 | SEWAGE | Group: Sanitary 74
Port_282900_0 | SEWAGE | Group: Sanitary 75
Port_282900_1 | SEWAGE | Group: Sanitary 75
Port_282902_0 | SEWAGE | Group: Sanitary 76
Port_282902_1 | SEWAGE | Group: Sanitary 76
Port_282904_0 | SEWAGE | Group: Sanitary 77
Port_282904_1 | SEWAGE | Group: Sanitary 77
Port_282906_0 | SEWAGE | Group: Sanitary 78
Port_282906_1 | SEWAGE | Group: Sanitary 78
Port_282908_0 | SEWAGE | Group: Sanitary 79
Port_282908_1 | SEWAGE | Group: Sanitary 79
Port_282910_0 | SEWAGE | Group: Sanitary 80
Port_282910_1 | SEWAGE | Group: Sanitary 80
Port_282912_0 | SEWAGE | Group: Sanitary 81
Port_282912_1 | SEWAGE | Group: Sanitary 81
Port_282914_0 | SEWAGE | Group: Sanitary 82
Port_282914_1 | SEWAGE | Group: Sanitary 82
Port_282916_0 | SEWAGE | Group: Sanitary 83
Port_282916_1 | SEWAGE | Group: Sanitary 83
Port_282918_0 | SEWAGE | Group: Sanitary 84
Port_282918_1 | SEWAGE | Group: Sanitary 84
Port_283465_2
Port_283465_3
Port_283466_1 | SEWAGE
Port_283466_2 | SEWAGE
Port_283562_2
Port_283562_3
Port_283563_1 | SEWAGE
Port_283563_2 | SEWAGE
Port_376685_5
Port_376685_6
Port_376685_8
Port_376685_9
Port_376823_5
Port_376823_6
Port_376823_8
Port_376823_9
Port_376869_5
Port_376869_6
Port_376869_8
Port_376869_9
Port_376871_5
Port_376871_6
Port_376871_8
Port_376871_9
Port_376878_5
Port_376878_6
Port_376878_8
Port_376878_9
Port_376880_5
Port_376880_6
Port_376880_8
Port_376880_9
Port_376889_5
Port_376889_6
Port_376889_8
Port_376889_9
Port_376891_5
Port_376891_6
Port_376891_8
Port_376891_9
Port_377185_5
Port_377185_6
Port_377185_8
Port_377185_9
Port_377187_5
Port_377187_6
Port_377187_8
Port_377187_9
Port_377188_5
Port_377188_6
Port_377188_8
Port_377188_9
Port_377190_5
Port_377190_6
Port_377190_8
Port_377190_9
Port_377191_5
Port_377191_6
Port_377191_8
Port_377191_9
Port_377193_5
Port_377193_6
Port_377193_8
Port_377193_9
Port_377194_5 | SEWAGE | Group: Sanitary 85
Port_377194_6 | SEWAGE | Group: Sanitary 85
Port_377194_8 | SEWAGE | Group: Sanitary 85
Port_377194_9 | SEWAGE | Group: Sanitary 85
Port_377196_5
Port_377196_6
Port_377196_8
Port_377196_9
Port_394206_5
Port_394206_6
Port_394206_8
Port_394206_9
Port_394207_5
Port_394207_6
Port_394207_8
Port_394207_9
Port_394208_5
Port_394208_6
Port_394208_8
Port_394208_9
Port_394209_5
Port_394209_6
Port_394209_8
Port_394209_9
Port_394210_5
Port_394210_6
Port_394210_8
Port_394210_9
Port_394211_5
Port_394211_6
Port_394211_8
Port_394211_9
Port_394212_5
Port_394212_6
Port_394212_8
Port_394212_9
Port_394213_5
Port_394213_6
Port_394213_8
Port_394213_9

# IfcDistributionSystem: Sanitary (85)
PredefinedType: SEWAGE
Pset_DistributionSystemCommon - Reference: Piping System:Sanitary
Name
Sanitary 1
Sanitary 2
Sanitary 3
Sanitary 4
Sanitary 5
Sanitary 6
Sanitary 7
Sanitary 8
Sanitary 9
Sanitary 10
Sanitary 11
Sanitary 12
Sanitary 13
Sanitary 14
Sanitary 15
Sanitary 16
Sanitary 17
Sanitary 18
Sanitary 19
Sanitary 20
Sanitary 21
Sanitary 22
Sanitary 23
Sanitary 24
Sanitary 25
Sanitary 26
Sanitary 27
Sanitary 28
Sanitary 29
Sanitary 30
Sanitary 33
Sanitary 34
Sanitary 35
Sanitary 36
Sanitary 37
Sanitary 38
Sanitary 41
Sanitary 42
Sanitary 43
Sanitary 44
Sanitary 45
Sanitary 46
Sanitary 31
Sanitary 32
Sanitary 39
Sanitary 40
Sanitary 47
Sanitary 48
Sanitary 49
Sanitary 50
Sanitary 51
Sanitary 52
Sanitary 53
Sanitary 54
Sanitary 55
Sanitary 56
Sanitary 57
Sanitary 58
Sanitary 59
Sanitary 60
Sanitary 61
Sanitary 62
Sanitary 63
Sanitary 64
Sanitary 65
Sanitary 66
Sanitary 67
Sanitary 68
Sanitary 69
Sanitary 70
Sanitary 71
Sanitary 72
Sanitary 73
Sanitary 74
Sanitary 75
Sanitary 76
Sanitary 77
Sanitary 78
Sanitary 79
Sanitary 80
Sanitary 81
Sanitary 82
Sanitary 83
Sanitary 84
Sanitary 85

# IfcPipeFitting: AWADUKT PP SN10 Bend:Blue (24)
In: Ground floor
Type - Material: AWADUKT PP SN10 Blue
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP SN10 Bend; T1: APP DSM; T2: DAPP SN10 Bend; T3: APP SN10 Bend; Type DSM: AWADUKT PP Union DSM : Blue No PID
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Blue; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Blue
Type - Materials and Finishes - APP: AWADUKT PP SN10 Blue
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: AWADUKT PP SN10 Bend:Blue; sets with these values: 2
Other - Family: AWADUKT PP SN10 Bend; Family and Type: AWADUKT PP SN10 Bend: Blue; IsCustom: no; Type: Blue; Type Id: 211504
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP SN10 Bend:Blue:...) | L1 (mm) | L1+S2 (mm) | R1 (mm) | S2 (mm) | Z1 (mm) | Z2 (mm) = Z4 (mm) | Z3 (mm) | Angle (deg) = Angle Check (deg) | Area (m2) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
229367 | 121 | 125 | 68.5521 | 4 | 66.2 | 66 | 217.6 | 88 | 0.0894191 | 110 | 102.4 | 110 mmø-110 mmø | 0.000310353 | AWADUKT PP BLUE elbow DN 110, 88 degree | 4007360502324 | 12474411056 | 0.38
229721 | 170 | 174 | 105.21 | 4 | 101.6 | 99 | 315.6 | 88 | 0.174601 | 160 | 149 | 160 mmø-160 mmø | 0.000902014 | AWADUKT PP BLUE elbow DN 160, 88 degree | 4007360293840 | 12474811056 | 1.029
229778 | 207 | 211.5 | 134.619 | 4.5 | 130 | 122 | 395.6 | 88 | 0.26355 | 200 | 186.2 | 200 mmø-200 mmø | 0.00172392 | AWADUKT PP BLUE elbow DN 200, 88 degree | 4007360345747 | 12476511056 | 1.707
229842 | 272 | 278 | 186.913 | 6 | 180.5 | 152 | 494.4 | 88 | 0.42459 | 250 | 232.8 | 250 mmø-250 mmø | 0.00349316 | AWADUKT PP BLUE elbow DN 250, 88 degree | 4067936796113 | 12476911056 | 3.278
229890 | 316 | 323 | 216.426 | 7 | 209 | 192 | 623 | 88 | 0.623732 | 315 | 293.4 | 315 mmø-315 mmø | 0.006453 | AWADUKT PP BLUE elbow DN 315, 88 degree | 4062178644932 | 12477311056 | 5.83
229934 | 394 | 403 | 270.895 | 9 | 261.6 | 237.3 | 791.1 | 88 | 0.988009 | 400 | 372.6 | 400 mmø-400 mmø | 0.013 | AWADUKT PP BLUE elbow DN 400, 88 degree | 4062178644918 | 12373131056 | 12.32
230252 | 87 | 91 | 77.7377 | 4 | 32.2 | 29 | 165 | 45 | 0.0746612 | 110 | 102.4 | 110 mmø-110 mmø | 0.000254271 | AWADUKT PP BLUE elbow DN 110, 45 degree | 4007360502317 | 12474311056 | 0.304
230256 | 119 | 123 | 125.781 | 4 | 52.1 | 42 | 240 | 45 | 0.14339 | 160 | 149 | 160 mmø-160 mmø | 0.000730349 | AWADUKT PP BLUE elbow DN 160, 45 degree | 4007360634650 | 13209851016 | 0.698
230260 | 148 | 152.5 | 171.409 | 4.5 | 71 | 63 | 300 | 45 | 0.219789 | 200 | 186.2 | 200 mmø-200 mmø | 0.00142197 | AWADUKT PP BLUE elbow DN 200, 45 degree | 4007360342814 | 12476411056 | 1.318
230264 | 197 | 203 | 254.7 | 6 | 105.5 | 78 | 375 | 45 | 0.358582 | 250 | 232.8 | 250 mmø-250 mmø | 0.00292548 | AWADUKT PP BLUE elbow DN 250, 45 degree | 4007360502393 | 12476811056 | 2.58
230268 | 222 | 229 | 277.635 | 7 | 115 | 98 | 472.5 | 45 | 0.514449 | 315 | 293.4 | 315 mmø-315 mmø | 0.00527271 | AWADUKT PP BLUE elbow DN 315, 45 degree | 4007360502423 | 12477211016 | 4.62
230272 | 282 | 291 | 361.166 | 9 | 149.6 | 120 | 600 | 45 | 0.827323 | 400 | 372.6 | 400 mmø-400 mmø | 0.0107986 | AWADUKT PP BLUE elbow DN 400, 45 degree | 4062178564490 | 12393621056 | 9.67
230359 | 78 | 82 | 86.5836 | 4 | 23.2 | 19 | 146.7 | 30 | 0.0694164 | 110 | 102.4 | 110 mmø-110 mmø | 0.000234341 | AWADUKT PP BLUE elbow DN 110, 30 degree | 4007360502300 | 12474211056 | 0.28
230363 | 106 | 110 | 145.923 | 4 | 39.1 | 28 | 213.3 | 30 | 0.132526 | 160 | 149 | 160 mmø-160 mmø | 0.000670598 | AWADUKT PP BLUE elbow DN 160, 30 degree | 4007360640446 | 13209751016 | 0.625
230367 | 132 | 136.5 | 205.263 | 4.5 | 55 | 47 | 266.7 | 30 | 0.20332 | 200 | 186.2 | 200 mmø-200 mmø | 0.00130833 | AWADUKT PP BLUE elbow DN 200, 30 degree | 4007360342821 | 12476311056 | 1.192
230371 | 177 | 183 | 319.09 | 6 | 85.5 | 58 | 333.3 | 30 | 0.333582 | 250 | 232.8 | 250 mmø-250 mmø | 0.00271048 | AWADUKT PP BLUE elbow DN 250, 30 degree | 4007360502386 | 12476711056 | 2.346
230375 | 197 | 204 | 335.885 | 7 | 90 | 73 | 420 | 30 | 0.474134 | 315 | 293.4 | 315 mmø-315 mmø | 0.00483732 | AWADUKT PP BLUE elbow DN 315, 30 degree | 4007360502416 | 12477111016 | 4.15
230379 | 253 | 262 | 450.085 | 9 | 120.6 | 114 | 533.3 | 30 | 0.769076 | 400 | 372.6 | 400 mmø-400 mmø | 0.0100006 | AWADUKT PP BLUE elbow DN 400, 30 degree | 4062178564483 | 12393521056 | 9.15
230455 | 69 | 73 | 107.86 | 4 | 14.2 | 12 | 128.3 | 15 | 0.0637121 | 110 | 102.4 | 110 mmø-110 mmø | 0.000212665 | AWADUKT PP BLUE elbow DN 110, 15 degree | 4007360502294 | 12474111056 | 0.256
230459 | 94 | 98 | 205.845 | 4 | 27.1 | 18 | 186.7 | 15 | 0.121598 | 160 | 149 | 160 mmø-160 mmø | 0.000610494 | AWADUKT PP BLUE elbow DN 160, 15 degree | 4007360640422 | 13209651016 | 0.566
230463 | 117 | 121.5 | 303.83 | 4.5 | 40 | 32 | 233.3 | 15 | 0.186374 | 200 | 186.2 | 200 mmø-200 mmø | 0.00119141 | AWADUKT PP BLUE elbow DN 200, 15 degree | 4007360345730 | 12476211056 | 1.065
230467 | 159 | 165 | 512.713 | 6 | 67.5 | 39 | 291.7 | 15 | 0.308671 | 250 | 232.8 | 250 mmø-250 mmø | 0.00249626 | AWADUKT PP BLUE elbow DN 250, 15 degree | 4007360502379 | 12476611056 | 2.148
230471 | 173 | 180 | 501.32 | 7 | 66 | 50 | 367.5 | 15 | 0.431488 | 315 | 293.4 | 315 mmø-315 mmø | 0.00437676 | AWADUKT PP BLUE elbow DN 315, 15 degree | 4007360502409 | 12477011016 | 3.67
230475 | 226.6 | 235.6 | 715.52 | 9 | 94.2 | 69.7 | 466.7 | 15 | 0.710409 | 400 | 372.6 | 400 mmø-400 mmø | 0.00919685 | AWADUKT PP BLUE elbow DN 400, 15 degree | 4062178564476 | 12393421056 | 8.04

# IfcPipeFitting: AWADUKT PP SN10 Bend:Orange (24)
In: Ground floor
Type - Material: AWADUKT PP SN10
Type - Other - Category: Pipe Fittings; Family Name: AWADUKT PP SN10 Bend; T1: APP DSM; T2: DAPP SN10 Bend; T3: APP SN10 Bend; Type DSM: AWADUKT PP Union DSM : Orange No PID
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Description: Orange; ETIM Class code: EC003024; Manufacturer: REHAU; Model: AWADUKT PP; Type Name: Orange
Type - Materials and Finishes - APP: AWADUKT PP SN10
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: AWADUKT PP SN10 Bend:Orange; sets with these values: 2
Other - Family: AWADUKT PP SN10 Bend; IsCustom: no; Family and Type: AWADUKT PP SN10 Bend: Orange; Type: Orange; Type Id: 211502
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; Description long: -
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (AWADUKT PP SN10 Bend:Orange:...) | L1 (mm) | L1+S2 (mm) | R1 (mm) | S2 (mm) | Z1 (mm) | Z2 (mm) = Z4 (mm) | Z3 (mm) | Angle (deg) = Angle Check (deg) | Area (m2) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | ID1 (mm) | Size = Overall Size | Volume (m3) | GTIN | PID | Weight
282300 | 121 | 125 | 68.5521 | 4 | 66.2 | 66 | 217.6 | 88 | 0.0894191 | 110 | 102.4 | 110 mmø-110 mmø | 0.000310353 | 4007360242220 | 12474411001 | 0.38
282304 | 170 | 174 | 105.21 | 4 | 101.6 | 99 | 315.6 | 88 | 0.174601 | 160 | 149 | 160 mmø-160 mmø | 0.000902014 | 4007360318840 | 12474811002 | 1.029
282308 | 207 | 211.5 | 134.619 | 4.5 | 130 | 122 | 395.6 | 88 | 0.26355 | 200 | 186.2 | 200 mmø-200 mmø | 0.00172392 | 4007360335526 | 12476511002 | 1.707
282312 | 272 | 278 | 186.913 | 6 | 180.5 | 152 | 494.4 | 88 | 0.42459 | 250 | 232.8 | 250 mmø-250 mmø | 0.00349316 | 4007360318888 | 12476911002 | 3.278
282316 | 316 | 323 | 216.426 | 7 | 209 | 192 | 623 | 88 | 0.623732 | 315 | 293.4 | 315 mmø-315 mmø | 0.006453 | 4007360318925 | 12477311002 | 5.83
282320 | 394 | 403 | 270.895 | 9 | 261.6 | 237.3 | 791.1 | 88 | 0.988009 | 400 | 372.6 | 400 mmø-400 mmø | 0.013 | 4007360452964 | 12373131002 | 12.32
282336 | 87 | 91 | 77.7377 | 4 | 32.2 | 29 | 165 | 45 | 0.0746612 | 110 | 102.4 | 110 mmø-110 mmø | 0.000254271 | 4007360242213 | 12474311001 | 0.304
282340 | 119 | 123 | 125.781 | 4 | 52.1 | 42 | 240 | 45 | 0.14339 | 160 | 149 | 160 mmø-160 mmø | 0.000730349 | 4007360633486 | 13209851001 | 0.698
282344 | 148 | 152.5 | 171.409 | 4.5 | 71 | 63 | 300 | 45 | 0.219789 | 200 | 186.2 | 200 mmø-200 mmø | 0.00142197 | 4007360335519 | 12476411002 | 1.318
282348 | 197 | 203 | 254.7 | 6 | 105.5 | 78 | 375 | 45 | 0.358582 | 250 | 232.8 | 250 mmø-250 mmø | 0.00292548 | 4007360318871 | 12476811002 | 2.58
282352 | 222 | 229 | 277.635 | 7 | 115 | 98 | 472.5 | 45 | 0.514449 | 315 | 293.4 | 315 mmø-315 mmø | 0.00527271 | 4007360318918 | 12477211002 | 4.62
282356 | 282 | 291 | 361.166 | 9 | 149.6 | 120 | 600 | 45 | 0.827323 | 400 | 372.6 | 400 mmø-400 mmø | 0.0107986 | 4007360452995 | 12393621002 | 9.67
282372 | 78 | 82 | 86.5836 | 4 | 23.2 | 19 | 146.7 | 30 | 0.0694164 | 110 | 102.4 | 110 mmø-110 mmø | 0.000234341 | 4007360242206 | 12474211001 | 0.28
282376 | 106 | 110 | 145.923 | 4 | 39.1 | 28 | 213.3 | 30 | 0.132526 | 160 | 149 | 160 mmø-160 mmø | 0.000670598 | 4007360635527 | 13209751001 | 0.625
282380 | 132 | 136.5 | 205.263 | 4.5 | 55 | 47 | 266.7 | 30 | 0.20332 | 200 | 186.2 | 200 mmø-200 mmø | 0.00130833 | 4007360335502 | 12476311002 | 1.192
282384 | 177 | 183 | 319.09 | 6 | 85.5 | 58 | 333.3 | 30 | 0.333582 | 250 | 232.8 | 250 mmø-250 mmø | 0.00271048 | 4007360318864 | 12476711002 | 2.346
282388 | 197 | 204 | 335.885 | 7 | 90 | 73 | 420 | 30 | 0.474134 | 315 | 293.4 | 315 mmø-315 mmø | 0.00483732 | 4007360318901 | 12477111002 | 4.15
282392 | 253 | 262 | 450.085 | 9 | 120.6 | 114 | 533.3 | 30 | 0.769076 | 400 | 372.6 | 400 mmø-400 mmø | 0.0100006 | 4007360452988 | 12393521002 | 9.15
282408 | 69 | 73 | 107.86 | 4 | 14.2 | 12 | 128.3 | 15 | 0.0637121 | 110 | 102.4 | 110 mmø-110 mmø | 0.000212665 | 4007360241797 | 12474111001 | 0.256
282412 | 94 | 98 | 205.845 | 4 | 27.1 | 18 | 186.7 | 15 | 0.121598 | 160 | 149 | 160 mmø-160 mmø | 0.000610494 | 4007360635510 | 13209651001 | 0.566
282416 | 117 | 121.5 | 303.83 | 4.5 | 40 | 32 | 233.3 | 15 | 0.186374 | 200 | 186.2 | 200 mmø-200 mmø | 0.00119141 | 4007360335496 | 12476211002 | 1.065
282420 | 159 | 165 | 512.713 | 6 | 67.5 | 39 | 291.7 | 15 | 0.308671 | 250 | 232.8 | 250 mmø-250 mmø | 0.00249626 | 4007360318857 | 12476611002 | 2.148
